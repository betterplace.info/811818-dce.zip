Properties of the parts of a building model (IFC2X3), part 3 of 6

# IfcBuildingElementProxy: Revêtement 117, Plafond de base:Plafond_Générique_60x120cm:480342
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 118, Plafond de base:Plafond_Générique_60x120cm:480349
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 119, Plafond de base:Plafond_Générique_60x120cm:480356
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 12, Plafond de base:Plafond_Générique_60x120cm:361791
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 120, Plafond de base:Plafond_Générique_60x120cm:480363
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 121, Plafond de base:Plafond_Générique_60x120cm:480370
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 122, Plafond de base:Plafond_Générique_60x120cm:480377
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 123, Plafond_Générique_9:Plafond_Générique_9:627592
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 124, Plafond de base:Plafond_Générique_60x120cm:630584
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 125, Plafond de base:Plafond_Générique_60x120cm:630594
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 126, Plafond_Générique_1:Plafond_Générique_1:632553
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 127, Plafond_Générique_2:Plafond_Générique_2:632595
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 128, Plafond_Générique_3:Plafond_Générique_3:632626
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 129, Plafond_Générique_4:Plafond_Générique_4:632719
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 13, Plafond de base:Plafond_Générique_60x120cm:361921
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 130, Plafond_Générique_5:Plafond_Générique_5:632748
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 131, Plafond_Générique_6:Plafond_Générique_6:632777
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 132, Plafond_Générique_7:Plafond_Générique_7:632834
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 133, Plafond_Générique_8:Plafond_Générique_8:632863
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 134, Plafond_Générique_10:Plafond_Générique_10:633765
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 135, Plafond_Générique_11:Plafond_Générique_11:634276
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 136, Plafond_Générique_12:Plafond_Générique_12:634425
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 137, Plafond_Générique_13:Plafond_Générique_13:634589
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 138, Plafond_Générique_14:Plafond_Générique_14:636367
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 139, Plafond_Générique_15:Plafond_Générique_15:636938
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 14, Plafond de base:Plafond_Générique_60x120cm:361929
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 140, Plafond_Générique_16:Plafond_Générique_16:637496
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 141, Plafond_Générique_17:Plafond_Générique_17:637893
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 142, Plafond de base:Plafond_Générique_60x120cm:638218
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 143, Plafond de base:Plafond_Générique_60x120cm:638226
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 144, Plafond de base:Plafond_Générique_60x120cm:638234
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 145, Plafond de base:Plafond_Générique_60x120cm:638795
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 146, Plafond_Générique_18:Plafond_Générique_18:639170
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 147, Plafond de base:Plafond_Générique_60x120cm:639435
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 148, Plafond de base:Plafond_Générique_60x120cm:639546
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 149, Plafond de base:Plafond_Générique_60x120cm:639612
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 15, Plafond de base:Plafond_Générique_60x120cm:361937
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 150, Plafond de base:Plafond_Générique_60x120cm:639679
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 151, Plafond de base:Plafond_Générique_60x120cm:639728
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 152, Plafond de base:Plafond_Générique_60x120cm:639776
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 153, Plafond de base:Plafond_Générique_60x120cm:639841
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 154, Plafond de base:Plafond_Générique_60x120cm:639892
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 155, Plafond de base:Plafond_Générique_60x120cm:639951
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 156, Plafond de base:Plafond_Générique_60x120cm:640010
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 157, Plafond de base:Plafond_Générique_60x120cm:640102
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 158, Plafond de base:Plafond_Générique_60x120cm:640114
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 159, Plafond_Générique_19:Plafond_Générique_18:640998
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 16, Plafond de base:Plafond_Générique_60x120cm:361955
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 160, Plafond_Générique_20:Plafond_Générique_20:672200
In: R+2
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 161, Plafond de base:Plafond_Générique_60x120cm:1624434
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 162, Plafond de base:Plafond_Générique_60x120cm:1624473
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 163, Plafond de base:Plafond_Générique_60x120cm:1624524
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 164, Plafond_Générique_21:Plafond_Générique_21:704179
In: TOITURE
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 17, Plafond de base:Plafond_Générique_60x120cm:362012
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 18, Plafond de base:Plafond_Générique_60x120cm:362072
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 19, Plafond de base:Plafond_Générique_60x120cm:362254
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 2, Plafond de base:Plafond_Générique_60x120cm:360850
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 20, Plafond de base:Plafond_Générique_60x120cm:362920
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 21, Plafond de base:Plafond_Générique_60x120cm:363701
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 22, Plafond de base:Plafond_Générique_60x120cm:363711
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 23, Plafond de base:Plafond_Générique_60x120cm:363719
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 24, Plafond de base:Plafond_Générique_60x120cm:363736
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 25, Plafond de base:Plafond_Générique_60x120cm:364022
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 26, Plafond de base:Plafond_Générique_60x120cm:364114
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 27, Plafond de base:Plafond_Générique_60x120cm:364193
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 28, Plafond de base:Plafond_Générique_60x120cm:364250
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 29, Plafond de base:Plafond_Générique_60x120cm:364258
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 3, Plafond de base:Plafond_Générique_60x120cm:360858
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 30, Plafond de base:Plafond_Générique_60x120cm:364371
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 31, Plafond de base:Plafond_Générique_60x120cm:364500
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 32, Plafond de base:Plafond_Générique_60x120cm:364516
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 33, Plafond de base:Plafond_Générique_60x120cm:364526
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 34, Plafond de base:Plafond_Générique_60x120cm:364551
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 35, Plafond de base:Plafond_Générique_60x120cm:364603
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 36, Plafond de base:Plafond_Générique_60x120cm:364611
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 37, Plafond de base:Plafond_Générique_60x120cm:364979
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 38, Plafond de base:Plafond_Générique_60x120cm:366418
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 39, Plafond de base:Plafond_Générique_60x120cm:366445
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 4, Plafond de base:Plafond_Générique_60x120cm:360866
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 40, Plafond de base:Plafond_Générique_60x120cm:366498
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 41, Plafond de base:Plafond_Générique_60x120cm:366586
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 42, Plafond de base:Plafond_Générique_60x120cm:366598
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 43, Plafond de base:Plafond_Générique_60x120cm:366726
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 44, Plafond de base:Plafond_Générique_60x120cm:366952
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 45, Plafond de base:Plafond_Générique_60x120cm:367322
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 46, Plafond_Sous face de plancher:Plafond_Sous face de plancher:970681
In: 0. Étage
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 47, Plafond amphithéatre:Plafond amphithéatre:1193961
In: 0. Étage
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 48, Plafond de base:Plafond_Générique_60x120cm:478628
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 49, Plafond de base:Plafond_Générique_60x120cm:478637
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 5, Plafond de base:Plafond_Générique_60x120cm:360890
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 50, Plafond de base:Plafond_Générique_60x120cm:478644
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 51, Plafond de base:Plafond_Générique_60x120cm:478651
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 52, Plafond de base:Plafond_Générique_60x120cm:478660
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 53, Plafond de base:Plafond_Générique_60x120cm:478667
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 54, Plafond de base:Plafond_Générique_60x120cm:478674
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 55, Plafond de base:Plafond_Générique_60x120cm:478681
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 56, Plafond de base:Plafond_Générique_60x120cm:478688
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 57, Plafond de base:Plafond_Générique_60x120cm:478695
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 58, Plafond de base:Plafond_Générique_60x120cm:478702
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 59, Plafond de base:Plafond_Générique_60x120cm:478709
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 6, Plafond de base:Plafond_Générique_60x120cm:360955
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 60, Plafond de base:Plafond_Générique_60x120cm:478718
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 61, Plafond de base:Plafond_Générique_60x120cm:478725
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 62, Plafond de base:Plafond_Générique_60x120cm:478732
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 63, Plafond de base:Plafond_Générique_60x120cm:478749
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 64, Plafond de base:Plafond_Générique_60x120cm:478762
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 65, Plafond de base:Plafond_Générique_60x120cm:478773
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 66, Plafond de base:Plafond_Générique_60x120cm:478797
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 67, Plafond de base:Plafond_Générique_60x120cm:478816
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 68, Plafond de base:Plafond_Générique_60x120cm:478827
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 69, Plafond de base:Plafond_Générique_60x120cm:478838
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 7, Plafond de base:Plafond_Générique_60x120cm:360963
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 70, Plafond de base:Plafond_Générique_60x120cm:478849
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 71, Plafond de base:Plafond_Générique_60x120cm:478872
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 72, Plafond de base:Plafond_Générique_60x120cm:478883
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 73, Plafond de base:Plafond_Générique_60x120cm:478907
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 74, Plafond de base:Plafond_Générique_60x120cm:478918
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 75, Plafond de base:Plafond_Générique_60x120cm:478929
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 76, Plafond de base:Plafond_Générique_60x120cm:478950
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 77, Plafond de base:Plafond_Générique_60x120cm:478967
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 78, Plafond de base:Plafond_Générique_60x120cm:478974
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 79, Plafond de base:Plafond_Générique_60x120cm:478981
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 8, Plafond de base:Plafond_Générique_60x120cm:360979
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 80, Plafond de base:Plafond_Générique_60x120cm:478988
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 81, Plafond de base:Plafond_Générique_60x120cm:478995
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 82, Plafond de base:Plafond_Générique_60x120cm:479002
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 83, Plafond de base:Plafond_Générique_60x120cm:479009
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 84, Plafond de base:Plafond_Générique_60x120cm:479016
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 85, Plafond de base:Plafond_Générique_60x120cm:479025
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 86, Plafond de base:Plafond_Générique_60x120cm:479032
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 87, Plafond de base:Plafond_Générique_60x120cm:479039
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 88, Plafond de base:Plafond_Générique_60x120cm:479046
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 89, Plafond de base:Plafond_Générique_60x120cm:479053
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 9, Plafond de base:Plafond_Générique_60x120cm:360995
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 90, Plafond de base:Plafond_Générique_60x120cm:479064
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 91, Plafond de base:Plafond_Générique_60x120cm:479071
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 92, Plafond de base:Plafond_Générique_60x120cm:479078
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 93, Plafond de base:Plafond_Générique_60x120cm:479085
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 94, Plafond de base:Plafond_Générique_60x120cm:479094
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 95, Plafond de base:Plafond_Générique_60x120cm:479101
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 96, Plafond de base:Plafond_Générique_60x120cm:479108
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 97, Plafond de base:Plafond_Générique_60x120cm:479115
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 98, Plafond de base:Plafond_Générique_60x120cm:479122
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 99, Plafond de base:Plafond_Générique_60x120cm:623282
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Révetement 100 (134)
Material: Révetement
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_10cm:...) | In | Niveau
321400 | 0. Étage | Niveau: RDC
321405 | 0. Étage | Niveau: RDC
321805 | 0. Étage | Niveau: RDC
326714 | 0. Étage | Niveau: RDC
326780 | 0. Étage | Niveau: RDC
338776 | 0. Étage | Niveau: RDC
338858 | 0. Étage | Niveau: RDC
345359 | 0. Étage | Niveau: RDC
345464 | 0. Étage | Niveau: RDC
348078 | 0. Étage | Niveau: RDC
348292 | 0. Étage | Niveau: RDC
348378 | 0. Étage | Niveau: RDC
348466 | 0. Étage | Niveau: RDC
348560 | 0. Étage | Niveau: RDC
352885 | 0. Étage | Niveau: RDC
353018 | 0. Étage | Niveau: RDC
353079 | 0. Étage | Niveau: RDC
353185 | 0. Étage | Niveau: RDC
353256 | 0. Étage | Niveau: RDC
353358 | 0. Étage | Niveau: RDC
353430 | 0. Étage | Niveau: RDC
353486 | 0. Étage | Niveau: RDC
353603 | 0. Étage | Niveau: RDC
353776 | 0. Étage | Niveau: RDC
354040 | 0. Étage | Niveau: RDC
354177 | 0. Étage | Niveau: RDC
354272 | 0. Étage | Niveau: RDC
354371 | 0. Étage | Niveau: RDC
354472 | 0. Étage | Niveau: RDC
354592 | 0. Étage | Niveau: RDC
354816 | 0. Étage | Niveau: RDC
358286 | 0. Étage | Niveau: RDC
358390 | 0. Étage | Niveau: RDC
358534 | 0. Étage | Niveau: RDC
358652 | 0. Étage | Niveau: RDC
358743 | 0. Étage | Niveau: RDC
358815 | 0. Étage | Niveau: RDC
358979 | 0. Étage | Niveau: RDC
611852 | 0. Étage | Niveau: RDC
1626465 | 0. Étage | Niveau: RDC
457247 | 0. Étage | Niveau: RDC
456872 | 0. Étage | Niveau: RDC
395467 | R+1 | Niveau: R+1
396597 | R+1 | Niveau: R+1
396709 | R+1 | Niveau: R+1
396836 | R+1 | Niveau: R+1
396926 | R+1 | Niveau: R+1
396952 | R+1 | Niveau: R+1
397002 | R+1 | Niveau: R+1
397033 | R+1 | Niveau: R+1
397165 | R+1 | Niveau: R+1
397260 | R+1 | Niveau: R+1
400027 | R+1 | Niveau: R+1
400104 | R+1 | Niveau: R+1
400186 | R+1 | Niveau: R+1
401173 | R+1 | Niveau: R+1
401284 | R+1 | Niveau: R+1
401388 | R+1 | Niveau: R+1
401431 | R+1 | Niveau: R+1
401457 | R+1 | Niveau: R+1
401535 | R+1 | Niveau: R+1
401562 | R+1 | Niveau: R+1
401657 | R+1 | Niveau: R+1
401714 | R+1 | Niveau: R+1
401791 | R+1 | Niveau: R+1
401811 | R+1 | Niveau: R+1
401863 | R+1 | Niveau: R+1
401950 | R+1 | Niveau: R+1
402022 | R+1 | Niveau: R+1
402106 | R+1 | Niveau: R+1
403248 | R+1 | Niveau: R+1
403299 | R+1 | Niveau: R+1
403380 | R+1 | Niveau: R+1
403417 | R+1 | Niveau: R+1
403484 | R+1 | Niveau: R+1
403505 | R+1 | Niveau: R+1
403573 | R+1 | Niveau: R+1
403598 | R+1 | Niveau: R+1
403638 | R+1 | Niveau: R+1
403747 | R+1 | Niveau: R+1
403824 | R+1 | Niveau: R+1
405276 | R+1 | Niveau: R+1
405453 | R+1 | Niveau: R+1
405540 | R+1 | Niveau: R+1
405971 | R+1 | Niveau: R+1
406059 | R+1 | Niveau: R+1
411979 | R+1 | Niveau: R+1
419164 | R+1 | Niveau: R+1
506422 | R+1 | Niveau: R+1
536234 | R+1 | Niveau: R+1
612018 | R+1 | Niveau: R+1
479333 | R+1 | Niveau: R+1
1526964 | R+2 | Niveau: R+2
638051 | R+2 | Niveau: R+2
631842 | R+2 | Niveau: R+2
631687 | R+2 | Niveau: R+2
438117 | R+2 | Niveau: R+2
438219 | R+2 | Niveau: R+2
438304 | R+2 | Niveau: R+2
438383 | R+2 | Niveau: R+2
438482 | R+2 | Niveau: R+2
439849 | R+2 | Niveau: R+2
441643 | R+2 | Niveau: R+2
441736 | R+2 | Niveau: R+2
441811 | R+2 | Niveau: R+2
441948 | R+2 | Niveau: R+2
442101 | R+2 | Niveau: R+2
442136 | R+2 | Niveau: R+2
442191 | R+2 | Niveau: R+2
444445 | R+2 | Niveau: R+2
444548 | R+2 | Niveau: R+2
444611 | R+2 | Niveau: R+2
444679 | R+2 | Niveau: R+2
444769 | R+2 | Niveau: R+2
444813 | R+2 | Niveau: R+2
444864 | R+2 | Niveau: R+2
444965 | R+2 | Niveau: R+2
445049 | R+2 | Niveau: R+2
445120 | R+2 | Niveau: R+2
445166 | R+2 | Niveau: R+2
445216 | R+2 | Niveau: R+2
445352 | R+2 | Niveau: R+2
3 x 445435 | R+2 | Niveau: R+2
445515 | R+2 | Niveau: R+2
445584 | R+2 | Niveau: R+2
445681 | R+2 | Niveau: R+2
445750 | R+2 | Niveau: R+2
445838 | R+2 | Niveau: R+2
445878 | R+2 | Niveau: R+2
445939 | R+2 | Niveau: R+2
445998 | R+2 | Niveau: R+2
446055 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Révetement 150 (36)
Material: Révetement
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_15cm:...) | In | Niveau
334037 | 0. Étage | Niveau: RDC
335356 | 0. Étage | Niveau: RDC
335997 | 0. Étage | Niveau: RDC
336139 | 0. Étage | Niveau: RDC
336266 | 0. Étage | Niveau: RDC
338183 | 0. Étage | Niveau: RDC
339809 | 0. Étage | Niveau: RDC
344527 | 0. Étage | Niveau: RDC
352388 | 0. Étage | Niveau: RDC
392229 | 0. Étage | Niveau: RDC
413783 | 0. Étage | Niveau: RDC
454432 | 0. Étage | Niveau: RDC
454525 | 0. Étage | Niveau: RDC
454594 | 0. Étage | Niveau: RDC
394478 | R+1 | Niveau: R+1
394851 | R+1 | Niveau: R+1
399218 | R+1 | Niveau: R+1
399339 | R+1 | Niveau: R+1
403954 | R+1 | Niveau: R+1
404079 | R+1 | Niveau: R+1
408583 | R+1 | Niveau: R+1
408696 | R+1 | Niveau: R+1
408751 | R+1 | Niveau: R+1
408798 | R+1 | Niveau: R+1
408843 | R+1 | Niveau: R+1
437233 | R+2 | Niveau: R+2
437391 | R+2 | Niveau: R+2
438631 | R+2 | Niveau: R+2
438727 | R+2 | Niveau: R+2
442770 | R+2 | Niveau: R+2
442855 | R+2 | Niveau: R+2
443387 | R+2 | Niveau: R+2
443447 | R+2 | Niveau: R+2
446373 | R+2 | Niveau: R+2
446425 | R+2 | Niveau: R+2
446469 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Révetement 170 (3)
In: 0. Étage
Material: Révetement
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_17cm:...)
328224
334212
457468

# IfcBuildingElementProxy: Révetement 180 (178)
Material: Révetement
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Pset_Murs, Phase | Pset_Murs, Niveau
Mur de base:Mur_Générique_18cm:321401 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:321403 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:326081 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:327604 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:327896 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:328049 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:328463 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:329922 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:330066 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:330145 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:331085 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:333067 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:333405 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:333540 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:333606 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:333669 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:334818 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:334915 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:336513 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:338414 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:338644 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:339129 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:340008 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:340267 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:340390 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:340538 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:340651 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:341693 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:344845 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:345079 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:345165 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:348723 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:349137 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:349285 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:349447 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:349567 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:349685 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:349863 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:350032 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:350145 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:350484 | 0. Étage | Existant | Niveau: RDC
2 x Mur de base:Mur_Générique_18cm:350890 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:350994 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:351082 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:351755 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:362230 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:364931 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:413418 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:455979 | 0. Étage | Existant | Niveau: RDC
Sol:Dalle en béton - 180 mm:460765 | 0. Étage | Pset_Sols - Phase: Existant; Niveau: Niveau: RDC
Mur de base:Mur_Générique_18cm:499907 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:499912 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:499915 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:499917 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:500721 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:501000 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507634 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507707 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507820 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507878 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507901 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507924 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507947 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:507977 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:1527031 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:327217 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:327422 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:321406 | 0. Étage | Existant | Niveau: RDC
Mur de base:Mur_Générique_18cm:393144 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:393145 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:393150 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:393151 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:393152 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:393153 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:393523 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:394268 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:394432 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:394581 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:395672 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:395752 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:395812 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:395916 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:398643 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:399027 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:399585 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:399801 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:400595 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:400951 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:401028 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:401076 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:405611 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:405748 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:405814 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:405887 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:406349 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:406411 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:406460 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:406982 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:407187 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:407694 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:407782 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:407842 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:411069 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:412790 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:419528 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:474256 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:474359 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:474442 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:474571 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:479214 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:499895 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:499942 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:499943 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:499948 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:499949 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:501701 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:501821 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508120 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508121 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508122 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508123 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508124 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508125 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508126 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508127 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:536066 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:536698 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:624474 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:1665432 | R+1 | Existant | Niveau: R+1
Mur de base:Mur_Générique_18cm:508219 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:508218 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:508217 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:508216 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:508215 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:508214 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:508213 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:508212 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:640688 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:640576 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:640503 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:505459 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:436669 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:436821 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:436894 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:436997 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:437149 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:437796 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:437907 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:437959 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:438971 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:440002 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:440089 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:440165 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:440254 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:443847 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:443887 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:444033 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:444154 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:444300 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:446257 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:448774 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:449105 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:449190 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:449321 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:449718 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:449984 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:450159 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:474104 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:479213 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:480323 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:502534 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:504409 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:504554 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:504555 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:504675 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:504842 | R+2 | Existant | Niveau: R+2
Mur de base:Mur_Générique_18cm:621126 | TOITURE | Existant | Niveau: TOITURE

# IfcBuildingElementProxy: Révetement 20 (7)
In: R+2
Material: Révetement
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Révetement 200 (7)
Material: Révetement
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:...) | In | Niveau
Mur_Générique_20cm:331389 | 0. Étage | Niveau: RDC
Mur_Générique_20cm:454852 | 0. Étage | Niveau: RDC
Mur_Générique_20cm:454932 | 0. Étage | Niveau: RDC
Mur_Générique_18cm:1527031 | 0. Étage | Niveau: RDC
Mur_Générique_20cm:1490858 | R+2 | Niveau: R+2
Mur_Générique_20cm:1490721 | R+2 | Niveau: R+2
Mur_Générique_20cm:1421627 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Révetement 250 (2)
In: 0. Étage
Material: Révetement
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
DALLE-012
Mur de base:Mur_Générique_25cm:1028338 | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC

# IfcBuildingElementProxy: Révetement 261 (2)
In: 0. Étage
Material: Révetement
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_26.14cm:...)
458458
458375

# IfcBuildingElementProxy: Révetement 280 (61)
Material: Révetement
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:...) | In | Niveau
Mur_Générique_28cm:272174 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:272175 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:317595 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:321399 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:324656 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:329402 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:329483 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:344967 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:349099 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:350248 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:350335 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:350775 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:352022 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:413094 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:413194 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:618299 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:620714 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:1522665 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:619915 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:321398 | 0. Étage | Niveau: RDC
Mur_Générique_28cm:393146 | R+1 | Niveau: R+1
Mur_Générique_28cm:393148 | R+1 | Niveau: R+1
Mur_Générique_28cm:409410 | R+1 | Niveau: R+1
Mur_Générique_28cm:409622 | R+1 | Niveau: R+1
Mur_Générique_28cm:410111 | R+1 | Niveau: R+1
Mur_Générique_28cm:412306 | R+1 | Niveau: R+1
Mur_Générique_28cm:412549 | R+1 | Niveau: R+1
Mur_Générique_28cm:479742 | R+1 | Niveau: R+1
Mur_Générique_28cm:533053 | R+1 | Niveau: R+1
Mur_Générique_28cm:533953 | R+1 | Niveau: R+1
Mur_Générique_28cm:534248 | R+1 | Niveau: R+1
Mur_Générique_28cm:534373 | R+1 | Niveau: R+1
Mur_Générique_28cm:534488 | R+1 | Niveau: R+1
Mur_Générique_28cm:536695 | R+1 | Niveau: R+1
Mur_Générique_28cm:536696 | R+1 | Niveau: R+1
Mur_Générique_28cm:536699 | R+1 | Niveau: R+1
Mur/Acrotere_Générique_28cm:553713 | R+1 | Niveau: R+1
Mur/Acrotere_Générique_28cm:553539 | R+2 | Niveau: R+2
Mur_Générique_28cm:422112 | R+2 | Niveau: R+2
Mur_Générique_28cm:422207 | R+2 | Niveau: R+2
Mur_Générique_28cm:422289 | R+2 | Niveau: R+2
Mur_Générique_28cm:422595 | R+2 | Niveau: R+2
Mur_Générique_28cm:422694 | R+2 | Niveau: R+2
Mur_Générique_28cm:422787 | R+2 | Niveau: R+2
Mur_Générique_28cm:422482 | R+2 | Niveau: R+2
Mur_Générique_28cm:443168 | R+2 | Niveau: R+2
Mur/Acrotere_Générique_28cm:617691 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:557032 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:553513 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:553512 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:553511 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:553509 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:553508 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:553507 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:553506 | TOITURE | Niveau: TOITURE
Mur/Acrotere_Générique_28cm:536934 | TOITURE | Niveau: Toiture_Niveau horizontal
Mur/Acrotere_Générique_28cm:536911 | TOITURE | Niveau: Toiture_Niveau horizontal
Mur/Acrotere_Générique_28cm:536889 | TOITURE | Niveau: Toiture_Niveau horizontal
Mur/Acrotere_Générique_28cm:536867 | TOITURE | Niveau: Toiture_Niveau horizontal
Mur/Acrotere_Générique_28cm:536866 | TOITURE | Niveau: Toiture_Niveau horizontal
Mur/Acrotere_Générique_28cm:536865 | TOITURE | Niveau: Toiture_Niveau horizontal

# IfcBuildingElementProxy: Révetement 300 (7)
Material: Révetement
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_30cm:...) | In | Niveau
324509 | 0. Étage | Niveau: RDC
341788 | 0. Étage | Niveau: RDC
458182 | 0. Étage | Niveau: RDC
458724 | 0. Étage | Niveau: RDC
534726 | R+1 | Niveau: R+1
536697 | R+1 | Niveau: R+1
564122 | R+1 | Niveau: R+1

# IfcBuildingElementProxy: Révetement 500 (8)
In: 0. Étage
Material: Révetement
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_50cm:...)
270796
270797
270798
270799
270800
270801
270802
270814

# IfcBuildingElementProxy: Révetement 600 (26)
In: 0. Étage
Material: Révetement
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Révetement 90 (8)
Material: Révetement
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_9cm:...) | In | Niveau
356614 | 0. Étage | Niveau: RDC
1417861 | 0. Étage | Niveau: RDC
1490731 | 0. Étage | Niveau: RDC
1490750 | 0. Étage | Niveau: RDC
400394 | R+1 | Niveau: R+1
499896 | R+1 | Niveau: R+1
505286 | R+2 | Niveau: R+2
474157 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Révetement D400, Poteau_Générique_Arrondi:b=400mm:372740
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: Révetement
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Toit 2, Toit_Générique:Toit_Générique:480400
In: TOITURE
Material: Toit_Générique
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Toit 3, Couvertine_Générique:Couvertine_Générique:536991
In: TOITURE
Material: Couvertine_Générique
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Toit_Générique 200 (3)
In: 0. Étage
Material: Toit_Générique
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Toit_Générique 98 (3)
In: 0. Étage
Material: Toit_Générique
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
2 x TOIT-011
TOIT-012

# IfcBuildingElementProxy: VOUTE POLYCARBONATE 5495 x 1229 (181)
In: TOITURE
Material: Vitrage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Vitrage 10 (5)
In: R+1
Material: Vitrage
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Vitrage 20 (8)
In: R+1
Material: Vitrage
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcCurtainWall: Elément Modèle 10, Panneau système:Vitré:1490688
In: 0. Étage
Material: Verre
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcCurtainWall: Elément Modèle 11, Panneau système:Vitré:1510845
In: 0. Étage
Material: Matériau de construction IFC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcCurtainWall: Elément Modèle 12, Panneau système:Vitré:1510846
In: 0. Étage
Material: Matériau de construction IFC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcCurtainWall: Elément Modèle 13, Panneau système:Vitré:1511525
In: 0. Étage
Material: Matériau de construction IFC
