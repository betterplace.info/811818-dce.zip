Properties of the parts of a building model (IFC2X3), part 5 of 6

# IfcCurtainWall: IFC Extruded (1493)
Name | In | Material
Panneau système:Vitré:1422506 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1422507 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425174 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425175 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425176 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425177 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425178 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425179 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425180 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425181 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425182 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425183 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425184 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425185 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425186 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425187 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425188 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1425189 | R+1 | Matériau de construction IFC
Meneau rectangulaire:50 x 50mm:1423092 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423093 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423094 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423095 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423096 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423097 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423098 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423099 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423100 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423101 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423102 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423103 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423104 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423105 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423106 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423107 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423174 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423175 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423176 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423177 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423178 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423179 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423180 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423181 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423182 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423183 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423184 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423185 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423186 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423187 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423188 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423189 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423210 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423211 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423236 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423237 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423242 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423243 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423256 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423257 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423270 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423271 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423282 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423283 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423294 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423295 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423306 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423307 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423308 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423309 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423315 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423316 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423327 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423328 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423339 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423340 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423351 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423352 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423358 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423359 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423360 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423361 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423367 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423368 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423379 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423380 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423386 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1423387 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425222 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425223 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425224 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425225 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425226 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425227 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425228 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425229 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425230 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425231 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425232 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425233 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425234 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425235 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425236 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425291 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425292 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425293 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425294 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425295 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425296 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425297 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425298 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425299 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425300 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425301 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425302 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425303 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425304 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425305 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1425306 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510775 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510776 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510777 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510778 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510783 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510785 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510786 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510787 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510788 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1510789 | R+1 | PVC - Gris foncé
Panneau système:Vitré:1490690 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511113 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511037 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511044 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511049 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511054 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511059 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511064 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511069 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511074 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511079 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511084 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511089 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511094 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511099 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511104 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511109 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511114 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511041 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511045 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511050 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511055 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511060 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511065 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511070 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511075 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511080 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511085 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511090 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511095 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511100 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511105 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511110 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511115 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511035 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511046 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511051 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511056 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511061 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511066 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511071 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511076 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511081 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511086 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511091 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511096 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511101 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511106 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511111 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511116 | R+1 | Matériau de construction IFC
Meneau rectangulaire:50 x 50mm:1511117 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511118 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511119 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511120 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511121 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511122 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511123 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511124 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511125 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511126 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511127 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511128 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511129 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511130 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511131 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511132 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511133 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511134 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511135 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511136 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511137 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511138 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511139 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511140 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511141 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511142 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511143 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511144 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511145 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511146 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511147 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511148 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511149 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511150 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511151 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511152 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511153 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511154 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511155 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511156 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511158 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511159 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511160 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511161 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511162 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511163 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511164 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511165 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511166 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511167 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511168 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511169 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511170 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511171 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511172 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511173 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511174 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511175 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511176 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511179 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511180 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511181 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511185 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511186 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511187 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511191 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511192 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511193 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511197 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511198 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511199 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511203 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511204 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511205 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511209 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511210 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511211 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511212 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511213 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511214 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511215 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511216 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511217 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511221 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511222 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511223 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511227 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511228 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511229 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511233 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511234 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511235 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511236 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511237 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511238 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511239 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511240 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511241 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511245 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511246 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511247 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511251 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511252 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511253 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511254 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511255 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511256 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511260 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511347 | R+1 | PVC - Gris foncé
Panneau système:Vitré:1490696 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511571 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512665 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512666 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512667 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512668 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512669 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512670 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512671 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512672 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512673 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512674 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512675 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512676 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1512677 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511503 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511624 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511620 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511613 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511606 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511602 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511598 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511702 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511591 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511584 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511580 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511576 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511572 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511505 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511625 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511621 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511614 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511607 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511603 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511599 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511703 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511592 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511585 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511581 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511577 | R+1 | Matériau de construction IFC
Panneau système:Vitré:1511573 | R+1 | Matériau de construction IFC
Meneau rectangulaire:50 x 50mm:1512194 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512197 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512198 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512199 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512206 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512207 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512208 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512209 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512210 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512211 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512212 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512213 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512214 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512215 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512216 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512217 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512218 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512244 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512245 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512246 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512247 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512248 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512249 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512250 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512251 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512252 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512253 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512254 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512255 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512256 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512295 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512296 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512297 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512298 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512299 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512300 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512301 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512302 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512303 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512304 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512305 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512306 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512307 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512334 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512511 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512512 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512513 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512526 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512527 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512528 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512538 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512539 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512540 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512547 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512548 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512549 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512556 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512557 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512558 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512565 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512566 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512567 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512577 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512578 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512579 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512586 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512587 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512588 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512594 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512595 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512596 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512603 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512604 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512605 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512615 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512616 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512617 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512627 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512628 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512629 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512638 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512642 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512643 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512644 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512651 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512678 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512679 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512680 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512681 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512702 | R+1 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512703 | R+1 | PVC - Gris foncé
Panneau système:Vitré:1420601 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1425912 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1425757 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426436 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426403 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426366 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426334 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426306 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426282 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426258 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426225 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426191 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426140 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426095 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426046 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1426001 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1425958 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1425913 | R+2 | Matériau de construction IFC
Meneau rectangulaire:50 x 50mm:1426573 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426574 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426581 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426584 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426585 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426586 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426587 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426588 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426589 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426590 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426591 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426592 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426593 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426594 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426595 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426596 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426597 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426598 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426599 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426685 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426686 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426698 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426699 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426708 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426709 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426715 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426716 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426725 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426726 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426735 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426736 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426745 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426746 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426755 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426756 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426762 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426763 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426773 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426774 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426780 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426781 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426786 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426787 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426796 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426797 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426806 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426807 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426816 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426817 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426822 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426826 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1426827 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427686 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427687 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427688 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427689 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427690 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427691 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427692 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427693 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427694 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427695 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427696 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427697 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427698 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427699 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427700 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1427701 | R+2 | PVC - Gris foncé
Panneau système:Vitré:1490692 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511305 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511039 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511264 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511267 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511270 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511273 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511276 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511279 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511282 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511285 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511288 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511291 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511294 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511297 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511300 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511303 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511306 | R+2 | Matériau de construction IFC
Meneau rectangulaire:50 x 50mm:1511307 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511308 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511309 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511310 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511311 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511312 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511313 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511314 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511315 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511316 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511317 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511318 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511319 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511320 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511321 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511322 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511323 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511324 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511325 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511326 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511327 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511328 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511329 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511330 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511331 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511332 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511333 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511334 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511335 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511336 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511337 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511338 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511339 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511340 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511342 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511343 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511345 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511349 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511350 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511351 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511353 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511355 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511357 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511359 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511361 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511362 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511364 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511366 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511368 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511369 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511370 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511372 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1511374 | R+2 | PVC - Gris foncé
Panneau système:Vitré:1490698 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511667 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511507 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511628 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511631 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511634 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511637 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511642 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511647 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511651 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511654 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511657 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511662 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511665 | R+2 | Matériau de construction IFC
Panneau système:Vitré:1511668 | R+2 | Matériau de construction IFC
Meneau rectangulaire:50 x 50mm:1512337 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512340 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512341 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512346 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512347 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512348 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512349 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512350 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512351 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512352 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512353 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512354 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512355 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512356 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512357 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512358 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512383 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512384 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512385 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512386 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512387 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512388 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512389 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512390 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512391 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512392 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512393 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512394 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512395 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512446 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512453 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512459 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512463 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512469 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512474 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512479 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512485 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512491 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512495 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512499 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512505 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512654 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512657 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:1512658 | R+2 | PVC - Gris foncé
Panneau système:Vitré:608557 | R+2 | Matériau de construction IFC
Panneau système:Vitré:608524 | R+2 | Matériau de construction IFC
Panneau système:Vitré:608481 | R+2 | Matériau de construction IFC
Meneau rectangulaire:180 x 50mm:609045 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609046 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609047 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609060 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609061 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609062 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609063 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609064 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 50mm:609065 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 25mm:609098 | R+2 | PVC - Gris foncé
Meneau rectangulaire:180 x 25mm:609103 | R+2 | PVC - Gris foncé
Panneau système:Vitré:600050 | R+2 | Matériau de construction IFC
Panneau système:Vitré:604338 | R+2 | Matériau de construction IFC
Panneau système:Vitré:604284 | R+2 | Matériau de construction IFC
Panneau système:Vitré:604239 | R+2 | Matériau de construction IFC
Panneau système:Vitré:604189 | R+2 | Matériau de construction IFC
Panneau système:Vitré:603307 | R+2 | Matériau de construction IFC
Panneau système:Vitré:603356 | R+2 | Matériau de construction IFC
Panneau système:Vitré:603413 | R+2 | Matériau de construction IFC
Panneau système:Vitré:603508 | R+2 | Matériau de construction IFC
Panneau système:Vitré:604392 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605148 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605149 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605150 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605151 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605152 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605153 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605154 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605155 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605156 | R+2 | Matériau de construction IFC
Panneau système:Vitré:605157 | R+2 | Matériau de construction IFC
Panneau système:Vitré:604662 | R+2 | Matériau de construction IFC
Meneau rectangulaire:150 x 50mm:604403 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604407 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604411 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604415 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604419 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604423 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604427 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604431 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604435 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604448 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604469 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604470 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604471 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:604696 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:604912 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:604913 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:604914 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:604915 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:604916 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:604917 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:604918 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605123 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605187 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605188 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605189 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605190 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605191 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605192 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605193 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605194 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605195 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605357 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605358 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605359 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605360 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605361 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605362 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605363 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605364 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605365 | R+2 | PVC - Gris foncé
Meneau rectangulaire:50 x 50mm:605366 | R+2 | PVC - Gris foncé
Meneau rectangulaire:150 x 50mm:605693 | R+2 | PVC - Gris foncé

# IfcCurtainWall: Mur-rideau:Simple panneau (25)
Pset_Murs - Phase: Existant
Name (Mur-rideau:Simple panneau:...) | In | Niveau
322239 | 0. Étage | Niveau: RDC
351484 | 0. Étage | Niveau: RDC
355432 | 0. Étage | Niveau: RDC
356232 | 0. Étage | Niveau: RDC
477935 | 0. Étage | Niveau: RDC
459788 | 0. Étage | Niveau: RDC
620873 | 0. Étage | Niveau: RDC
461655 | 0. Étage | Niveau: RDC
466749 | 0. Étage | Niveau: RDC
618298 | 0. Étage | Niveau: RDC
612501 | 0. Étage | Niveau: RDC
620336 | 0. Étage | Niveau: RDC
459072 | 0. Étage | Niveau: RDC
469240 | R+1 | Niveau: R+1
613354 | R+1 | Niveau: R+1
599516 | R+1 | Niveau: R+1
482970 | R+1 | Niveau: R+1
504946 | R+1 | Niveau: R+1
506704 | R+1 | Niveau: R+1
507084 | R+1 | Niveau: R+1
505201 | R+2 | Niveau: R+2
507011 | R+2 | Niveau: R+2
507429 | R+2 | Niveau: R+2
607079 | R+2 | Niveau: R+2
600049 | R+2 | Niveau: R+2

# IfcOpeningElement (406)
Name | In
5 x Mur de base:Mur_Générique_28cm:272174 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
2 x Mur de base:Mur_Générique_28cm:272175 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
9 x Mur de base:Mur_Générique_28cm:317595 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Mur de base:Mur_Générique_28cm:321399:1 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
3 x Mur de base:Mur_Générique_28cm:321399 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Mur de base:Mur_Générique_10cm:321400:1 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
4 x Me 011 | 0. Étage
3 x Mur de base:Mur_Générique_18cm:272172 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Mur de base:Mur_Générique_10cm:326780:1 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.80 x 2.04m:709129 | 0. Étage
Mur de base:Mur_Générique_18cm:327896 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_v2_2 vantaux battant:1.40 x 2.04m:952805 | 0. Étage
Mur de base:Mur_Générique_18cm:328049 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Fenêtre_Ouverture avec volé roulant:3.18 x 1.50 m:1185778 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:952858 | 0. Étage
Porte_1 battant:0.80 x 2.04m:709309 | 0. Étage
Porte_1 battant:0.70 x 2.04m:709474 | 0. Étage
Porte_1 battant:0.70 x 2.04m:709530 | 0. Étage
Porte_1 battant:0.70 x 2.04m:709571 | 0. Étage
Porte_1 battant:0.80 x 2.04m:709203 | 0. Étage
Porte_1 battant:0.80 x 2.04m:709261 | 0. Étage
Mur de base:Mur_Générique_18cm:333606 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Mur de base:Mur_Générique_18cm:333669 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Fenêtre_Ouverture avec volé roulant:4.93 x 1.50 m:1187858 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708656 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708608 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708562 | 0. Étage
Porte d'ascenseur:1.00 x 2.04 m:1405347 | 0. Étage
Mur de base:Mur_Générique_15cm:338183 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337318 | 0. Étage
Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337330 | 0. Étage
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337336 | 0. Étage
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337339 | 0. Étage
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337341 | 0. Étage
Porte_v3_2 vantaux battant:1.20 x 2.04m:956349 | 0. Étage
Porte_v3_2 vantaux battant:1.20 x 2.04m:956401 | 0. Étage
Porte_v3_2 vantaux battant:1.20 x 2.04m:956440 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708754 | 0. Étage
2 x PORTE-017 | 0. Étage
2 x M0-03 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708795 | 0. Étage
Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337323 | 0. Étage
Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1337324 | 0. Étage
Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337327 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:952988 | 0. Étage
Porte_v3_2 vantaux battant:1.20 x 2.04m:956481 | 0. Étage
Porte_v3_2 vantaux battant:1.20 x 2.04m:956517 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708864 | 0. Étage
Porte_1 battant:0.80 x 2.04m:710066 | 0. Étage
Porte_1 battant:0.80 x 2.04m:710161 | 0. Étage
Porte_1 battant:0.80 x 2.04m:710121 | 0. Étage
Porte_1 battant:0.70 x 2.04m:709836 | 0. Étage
Porte_1 battant:0.70 x 2.04m:709783 | 0. Étage
Porte_1 battant:0.70 x 2.04m:709884 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:952608 | 0. Étage
Porte_1 battant:0.90 x 2.04m:709008 | 0. Étage
Mur de base:Mur_Générique_28cm:344967 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.90 x 2.04m:708082 | 0. Étage
Porte_1 battant:0.90 x 2.04m:1526966 | 0. Étage
Mur de base:Mur_Générique_10cm:345464:1 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.90 x 2.04m:708418 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:945009 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708355 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708290 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708013 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707913 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707873 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707718 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707619 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:945008 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707394 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707576 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707479 | 0. Étage
Porte_v1_2 vantaux battant:1.80 x 2.04m:863851 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:952695 | 0. Étage
2 x Mur de base:Mur_Générique_28cm:350775 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.90 x 2.04m:707224 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707164 | 0. Étage
Porte_2 vantaux battant_Double sens:1.40 x 2.04m:887377 | 0. Étage
Porte_2 vantaux battant_1 sens:1.40 x 2.04m:1549998 | 0. Étage
Porte_1 battant:0.90 x 2.04m:706961 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707115 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707248 | 0. Étage
Porte_v1_2 vantaux battant:1.80 x 2.04m:862264 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707343 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707531 | 0. Étage
Fenêtre_Classe-couloir_v2.2:2.50 x 0.80 m:1361910 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707760 | 0. Étage
Fenêtre_Classe-couloir_v2.2:1.25 x 0.80 m:1366859 | 0. Étage
Porte_2 vantaux battant_Double sens:1.80 x 2.04m:890507 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707963 | 0. Étage
Porte_1 battant:0.90 x 2.04m:707817 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708245 | 0. Étage
Mur de base:Mur_Générique_10cm:272921 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_v2_2 vantaux battant:1.40 x 2.04m:953070 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:952647 | 0. Étage
Porte_1 battant:0.90 x 2.04m:708922 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:952352 | 0. Étage
M0-08 | 0. Étage
M0-09 | 0. Étage
Porte_v3_2 vantaux battant:1.20 x 2.04m:1419194 | 0. Étage
7 x Mur de base:Mur_Générique_9cm:356105 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_v3_2 vantaux battant:1.20 x 2.04m:1512771 | 0. Étage
Porte_v3_2 vantaux battant:1.20 x 2.04m:1512881 | 0. Étage
Porte_v3_2 vantaux battant:1.40 x 2.04m:1512836 | 0. Étage
Me 004 | 0. Étage
4 x Me 005 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:960236 | 0. Étage
Porte_v2_2 vantaux battant:1.40 x 2.04m:960112 | 0. Étage
M0-02 | 0. Étage
M0-01 | 0. Étage
M0-04 | 0. Étage
M0-05 | 0. Étage
M0-06 | 0. Étage
M0-07 | 0. Étage
M0-09b | 0. Étage
Porte_1 battant:0.90 x 2.04m:707424 | 0. Étage
2 x Mur de base:Mur_Générique_28cm:619915 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
4 x Mur de base:Mur_Générique_28cm:321398 | 0. Étage | Pset_Murs - Phase: Existant; Niveau: Niveau: RDC; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
2 x M0-09 | R+1
M1-11 | R+1
M1-10 | R+1
Sol:Dalle_Générique_20cm:380740:2 | R+1 | AC_Pset_RenovationAndPhasing - Renovation Status: Existing; Pset_Sols - Phase: Existant; Niveau: Niveau: R+1
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1358992 | R+1
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1359034 | R+1
Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1359228 | R+1
Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1359272 | R+1
Porte_1 battant:0.90 x 2.04m:710932 | R+1
Fenêtre_Classe-couloir_v4:5.00 x 0.80 m:1513977 | R+1
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337344 | R+1
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337343 | R+1
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337338 | R+1
Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337331 | R+1
Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337321 | R+1
Porte_v3_2 vantaux battant:1.20 x 2.04m:960406 | R+1
Porte_v3_2 vantaux battant:1.20 x 2.04m:960462 | R+1
Porte_v3_2 vantaux battant:1.20 x 2.04m:960507 | R+1
Mur de base:Mur_Générique_15cm:394478 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337329 | R+1
Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1337326 | R+1
Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337322 | R+1
Porte_v3_2 vantaux battant:1.20 x 2.04m:960594 | R+1
Porte_v3_2 vantaux battant:1.20 x 2.04m:960551 | R+1
Porte_v2_2 vantaux battant:1.40 x 2.04m:953386 | R+1
Porte_1 battant:0.90 x 2.04m:712236 | R+1
Porte_1 battant:0.90 x 2.04m:712175 | R+1
Porte_1 battant:0.90 x 2.04m:712058 | R+1
2 x Mur de base:Mur_Générique_18cm:272172 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.70 x 2.04m:714112 | R+1
Porte_1 battant:0.70 x 2.04m:714282 | R+1
Porte_1 battant:0.70 x 2.04m:714204 | R+1
Porte_1 battant:0.80 x 2.04m:712932 | R+1
Mur de base:Mur_Générique_7cm:396135 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.80 x 2.04m:712804 | R+1
Porte_1 battant:0.80 x 2.04m:712890 | R+1
Porte_1 battant:0.90 x 2.04m:712297 | R+1
Porte_1 battant:0.90 x 2.04m:711926 | R+1
Porte_1 battant:0.90 x 2.04m:711870 | R+1
Porte_1 battant:0.90 x 2.04m:711965 | R+1
Porte_1 battant:0.90 x 2.04m:710971 | R+1
Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1359446 | R+1
Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1359321 | R+1
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1359100 | R+1
Porte_1 battant:0.90 x 2.04m:711152 | R+1
Porte_1 battant:0.90 x 2.04m:711100 | R+1
Porte_1 battant:0.90 x 2.04m:711677 | R+1
Porte_1 battant:0.90 x 2.04m:711632 | R+1
Porte_1 battant:0.90 x 2.04m:711587 | R+1
Porte_1 battant:0.90 x 2.04m:711823 | R+1
3 x Mur de base:Mur_Générique_9cm:356105 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
T-2 Vantaux coulissant:2.55 x 0.80 cm:939840 | R+1
T-2 Vantaux coulissant:2.48 x 0.80 cm:938935 | R+1
T-2 Vantaux coulissant:2.60 x 0.80 cm:941255 | R+1
T-2 Vantaux coulissant:2.60 x 0.80 cm:941077 | R+1
Porte_1 battant:0.90 x 2.04m:711517 | R+1
Porte_1 battant:0.90 x 2.04m:712597 | R+1
Porte_1 battant:0.90 x 2.04m:711276 | R+1
Porte_1 battant:0.90 x 2.04m:711211 | R+1
Porte_1 battant:0.90 x 2.04m:712743 | R+1
Porte_1 battant:0.90 x 2.04m:712666 | R+1
Porte_1 battant:0.90 x 2.04m:710850 | R+1
Porte_1 battant:0.90 x 2.04m:710751 | R+1
2 x Porte_1 battant:0.90 x 2.04m:710642 | R+1
Porte_1 battant:0.90 x 2.04m:710589 | R+1
Porte_1 battant:0.90 x 2.04m:710541 | R+1
Porte_1 battant:0.90 x 2.04m:710339 | R+1
Porte_1 battant:0.90 x 2.04m:712434 | R+1
Porte_1 battant:0.90 x 2.04m:711477 | R+1
Porte_1 battant:0.90 x 2.04m:711389 | R+1
Porte_v3_2 vantaux battant:1.20 x 2.04m:960668 | R+1
Porte_1 battant:0.70 x 2.04m:713997 | R+1
Porte_1 battant:0.70 x 2.04m:713960 | R+1
Porte_1 battant:0.80 x 2.04m:712987 | R+1
Porte_1 battant:0.70 x 2.04m:714038 | R+1
Porte_1 battant:0.80 x 2.04m:713073 | R+1
Porte_1 battant:0.80 x 2.04m:713047 | R+1
Porte d'ascenseur:1.00 x 2.04 m:1405350 | R+1
Porte_1 battant:0.90 x 2.04m:712344 | R+1
Porte_1 battant:0.90 x 2.04m:711064 | R+1
Porte_1 battant:0.90 x 2.04m:711785 | R+1
Porte_1 battant:0.90 x 2.04m:710889 | R+1
Porte_1 battant:0.90 x 2.04m:712394 | R+1
Porte_v2_2 vantaux battant:1.40 x 2.04m:953322 | R+1
Porte_v2_2 vantaux battant:1.40 x 2.04m:953568 | R+1
Porte_v2_2 vantaux battant:1.40 x 2.04m:953276 | R+1
Porte_v2_2 vantaux battant:1.40 x 2.04m:953170 | R+1
3 x Mur de base:Mur_Générique_28cm:534488 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
4 x Mur de base:Mur_Générique_30cm:534726 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
5 x Mur de base:Mur_Générique_28cm:536695 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
