Properties of the parts of a building model (IFC2X3), part 2 of 6

# IfcBuildingElementProxy: Porte (Mur) 121, Porte_1 battant:0.70 x 2.04m:713997
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 122, Porte_1 battant:0.70 x 2.04m:713960
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 123, Porte_1 battant:0.80 x 2.04m:712987
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 124, Porte_1 battant:0.70 x 2.04m:714038
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 125, Porte_1 battant:0.80 x 2.04m:713073
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 126, Porte_1 battant:0.80 x 2.04m:713047
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 127, Porte d'ascenseur:1.00 x 2.04 m:1405350
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Métal
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 128, Porte_1 battant:0.90 x 2.04m:712344
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 129, Porte_1 battant:0.90 x 2.04m:711064
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 13, Porte d'ascenseur:1.00 x 2.04 m:1405347
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Métal
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 130, Porte_1 battant:0.90 x 2.04m:711785
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 131, Porte_1 battant:0.90 x 2.04m:710889
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 132, Porte_1 battant:0.90 x 2.04m:712394
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 133, Porte_v2_2 vantaux battant:1.40 x 2.04m:953322
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 134, Porte_v2_2 vantaux battant:1.40 x 2.04m:953568
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 135, Porte_v2_2 vantaux battant:1.40 x 2.04m:953276
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 136, Porte_v2_2 vantaux battant:1.40 x 2.04m:953170
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 137, Porte_v3_2 vantaux battant:1.20 x 2.04m:961173
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 138, Porte_v3_2 vantaux battant:1.20 x 2.04m:961120
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 139, Porte_v2_2 vantaux battant:1.40 x 2.04m:953748
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 14, Porte_v3_2 vantaux battant:1.20 x 2.04m:956349
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 140, Porte_v3_2 vantaux battant:1.20 x 2.04m:960999
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 141, Porte_v3_2 vantaux battant:1.20 x 2.04m:960954
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 142, Porte_1 battant:0.90 x 2.04m:714579
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 143, Porte_1 battant:0.90 x 2.04m:714780
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 144, Porte_1 battant:0.90 x 2.04m:714382
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 145, Porte_1 battant:0.90 x 2.04m:714527
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 146, Porte_1 battant:0.90 x 2.04m:714830
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 147, Porte_1 battant:0.90 x 2.04m:714992
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 148, Porte_1 battant:0.90 x 2.04m:715038
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 149, Porte_v3_2 vantaux battant:1.20 x 2.04m:961082
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 15, Porte_v3_2 vantaux battant:1.20 x 2.04m:956401
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 150, Porte_v3_2 vantaux battant:1.20 x 2.04m:961028
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 151, Porte_1 battant:0.90 x 2.04m:715097
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 152, Porte_1 battant:0.70 x 2.04m:713710
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 153, Porte_1 battant:0.70 x 2.04m:713542
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 154, Porte_1 battant:0.70 x 2.04m:713491
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 155, Porte_1 battant:0.80 x 2.04m:713435
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 156, Porte_1 battant:0.80 x 2.04m:713393
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 157, Porte_1 battant:0.80 x 2.04m:713335
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 158, Porte_1 battant:0.80 x 2.04m:713169
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 159, Porte_1 battant:0.80 x 2.04m:713204
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 16, Porte_v3_2 vantaux battant:1.20 x 2.04m:956440
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 160, Porte_1 battant:0.70 x 2.04m:713911
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 161, Porte_1 battant:0.70 x 2.04m:713819
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 162, Porte_1 battant:0.80 x 2.04m:713240
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 163, Porte_1 battant:0.70 x 2.04m:713758
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 164, Porte_v2_2 vantaux battant:1.40 x 2.04m:954420
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 165, Porte_1 battant:0.90 x 2.04m:715517
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 166, Porte_v2_2 vantaux battant:1.40 x 2.04m:954540
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 167, Porte_v2_2 vantaux battant:1.40 x 2.04m:954484
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 168, Porte_v2_2 vantaux battant:1.40 x 2.04m:954190
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 169, Porte_1 battant:0.90 x 2.04m:715905
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 17, Porte_1 battant:0.90 x 2.04m:708754
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 170, Porte_1 battant:0.90 x 2.04m:715848
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 171, Porte_1 battant:0.90 x 2.04m:715731
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 172, Porte_1 battant:0.90 x 2.04m:715672
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 173, Porte_1 battant:0.90 x 2.04m:715630
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 174, Porte_1 battant:0.90 x 2.04m:715572
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 175, Porte_1 battant:0.90 x 2.04m:715317
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 176, Porte_1 battant:0.90 x 2.04m:715296
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 177, Porte_1 battant:0.90 x 2.04m:715230
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 178, Porte_v2_2 vantaux battant:1.40 x 2.04m:954086
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 179, Porte_1 battant:0.90 x 2.04m:715952
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 18, Porte_1 battant:0.90 x 2.04m:708795
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 180, Porte_1 battant:0.90 x 2.04m:716162
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 181, Porte_1 battant:0.90 x 2.04m:716211
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 182, Porte_1 battant:0.90 x 2.04m:716083
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 183, Porte_1 battant:0.90 x 2.04m:716027
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 184, Porte_v2_2 vantaux battant:1.40 x 2.04m:954263
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 185, Porte_v2_2 vantaux battant:1.40 x 2.04m:954307
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 186, Porte_v2_2 vantaux battant:1.40 x 2.04m:954137
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 187, Porte_1 battant:0.90 x 2.04m:715768
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 188, Porte_1 battant:0.90 x 2.04m:715457
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 189, Porte_v2_2 vantaux battant:1.40 x 2.04m:954579
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 19, Porte_v2_2 vantaux battant:1.40 x 2.04m:952988
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 190, Porte_v2_2 vantaux battant:1.40 x 2.04m:954620
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 191, Porte_1 battant:0.90 x 2.04m:715411
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 192, Porte_1 battant:0.90 x 2.04m:715369
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 193, Porte_1 battant:0.90 x 2.04m:715810
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 194, Porte d'ascenseur:1.00 x 2.04 m:1405349
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Métal
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 195, Porte_1 battant:0.90 x 2.04m:714718
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 196, Porte_v2_2 vantaux battant:1.40 x 2.04m:953850
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 197, Porte_v2_2 vantaux battant:1.40 x 2.04m:953650
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 198, Porte_v2_2 vantaux battant:1.40 x 2.04m:954379
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 199, Porte_1 battant:0.90 x 2.04m:716364
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 2, Porte_v2_2 vantaux battant:1.40 x 2.04m:952805
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 20, Porte_v3_2 vantaux battant:1.20 x 2.04m:956481
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 200, Porte_v2_2 vantaux battant:1.40 x 2.04m:954031
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 201, Porte_v2_2 vantaux battant:1.40 x 2.04m:953979
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 202, Porte_1 battant:0.90 x 2.04m:716318
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 203, Porte_1 battant:0.90 x 2.04m:716279
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 204, Porte_1 battant:0.90 x 2.04m:1526965
In: R+2
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 21, Porte_v3_2 vantaux battant:1.20 x 2.04m:956517
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 22, Porte_1 battant:0.90 x 2.04m:708864
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 23, Porte_1 battant:0.80 x 2.04m:710066
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 24, Porte_1 battant:0.80 x 2.04m:710161
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 25, Porte_1 battant:0.80 x 2.04m:710121
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 26, Porte_1 battant:0.70 x 2.04m:709836
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 27, Porte_1 battant:0.70 x 2.04m:709783
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 28, Porte_1 battant:0.70 x 2.04m:709884
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 29, Porte_v2_2 vantaux battant:1.40 x 2.04m:952608
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 3, Porte_v2_2 vantaux battant:1.40 x 2.04m:952858
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 30, Porte_1 battant:0.90 x 2.04m:709008
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 32, Porte_1 battant:0.90 x 2.04m:708082
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 33, Porte_1 battant:0.90 x 2.04m:1526966
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 34, Porte_1 battant:0.90 x 2.04m:708418
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 35, Porte_v2_2 vantaux battant:1.40 x 2.04m:945009
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 36, Porte_1 battant:0.90 x 2.04m:708355
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 37, Porte_1 battant:0.90 x 2.04m:708290
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 38, Porte_1 battant:0.90 x 2.04m:708013
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 39, Porte_1 battant:0.90 x 2.04m:707913
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 4, Porte_1 battant:0.80 x 2.04m:709309
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 40, Porte_1 battant:0.90 x 2.04m:707873
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 41, Porte_1 battant:0.90 x 2.04m:707718
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 42, Porte_1 battant:0.90 x 2.04m:707619
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 43, Porte_v2_2 vantaux battant:1.40 x 2.04m:945008
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 44, Porte_1 battant:0.90 x 2.04m:707394
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 45, Porte_1 battant:0.90 x 2.04m:707576
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 46, Porte_1 battant:0.90 x 2.04m:707479
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 47, Porte_v1_2 vantaux battant:1.80 x 2.04m:863851
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 48, Porte_v2_2 vantaux battant:1.40 x 2.04m:952695
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 49, Porte_1 battant:0.90 x 2.04m:707424
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 5, Porte_1 battant:0.70 x 2.04m:709474
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 50, Porte_1 battant:0.90 x 2.04m:707224
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 51, Porte_1 battant:0.90 x 2.04m:707164
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 52, Porte_2 vantaux battant_Double sens:1.40 x 2.04m:887377
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 53, Porte_2 vantaux battant_1 sens:1.40 x 2.04m:1549998
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 54, Porte_1 battant:0.90 x 2.04m:706961
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 55, Porte_1 battant:0.90 x 2.04m:707115
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 56, Porte_1 battant:0.90 x 2.04m:707248
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 57, Porte_v1_2 vantaux battant:1.80 x 2.04m:862264
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 58, Porte_1 battant:0.90 x 2.04m:707343
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 59, Porte_1 battant:0.90 x 2.04m:707531
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 6, Porte_1 battant:0.70 x 2.04m:709530
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 60, Porte_1 battant:0.90 x 2.04m:707760
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 61, Porte_2 vantaux battant_Double sens:1.80 x 2.04m:890507
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 62, Porte_1 battant:0.90 x 2.04m:707963
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 63, Porte_1 battant:0.90 x 2.04m:707817
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 64, Porte_1 battant:0.90 x 2.04m:708245
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 65, Porte_v2_2 vantaux battant:1.40 x 2.04m:953070
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 66, Porte_v2_2 vantaux battant:1.40 x 2.04m:952647
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 67, Porte_1 battant:0.90 x 2.04m:708922
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 68, Porte_v2_2 vantaux battant:1.40 x 2.04m:952352
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 7, Porte_1 battant:0.70 x 2.04m:709571
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 70, Porte_v3_2 vantaux battant:1.20 x 2.04m:1419194
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 71, Porte_v3_2 vantaux battant:1.20 x 2.04m:1512771
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 72, Porte_v3_2 vantaux battant:1.20 x 2.04m:1512881
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 73, Porte_v3_2 vantaux battant:1.40 x 2.04m:1512836
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 74, Porte_v2_2 vantaux battant:1.40 x 2.04m:960236
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 75, Porte_v2_2 vantaux battant:1.40 x 2.04m:960112
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 76, Porte_1 battant:0.90 x 2.04m:710932
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 78, Porte_v3_2 vantaux battant:1.20 x 2.04m:960406
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 79, Porte_v3_2 vantaux battant:1.20 x 2.04m:960462
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 8, Porte_1 battant:0.80 x 2.04m:709203
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 80, Porte_v3_2 vantaux battant:1.20 x 2.04m:960507
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 81, Porte_v3_2 vantaux battant:1.20 x 2.04m:960594
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 82, Porte_v3_2 vantaux battant:1.20 x 2.04m:960551
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 83, Porte_v2_2 vantaux battant:1.40 x 2.04m:953386
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 84, Porte_1 battant:0.90 x 2.04m:712236
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 85, Porte_1 battant:0.90 x 2.04m:712175
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 86, Porte_1 battant:0.90 x 2.04m:712058
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 87, Porte_1 battant:0.70 x 2.04m:714112
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 88, Porte_1 battant:0.70 x 2.04m:714282
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 89, Porte_1 battant:0.70 x 2.04m:714204
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 9, Porte_1 battant:0.80 x 2.04m:709261
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 90, Porte_1 battant:0.80 x 2.04m:712932
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 91, Porte_1 battant:0.80 x 2.04m:712804
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 92, Porte_1 battant:0.80 x 2.04m:712890
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 93, Porte_1 battant:0.90 x 2.04m:712297
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 94, Porte_1 battant:0.90 x 2.04m:711926
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 95, Porte_1 battant:0.90 x 2.04m:711870
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 96, Porte_1 battant:0.90 x 2.04m:711965
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 97, Porte_1 battant:0.90 x 2.04m:710971
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 99, Porte_1 battant:0.90 x 2.04m:711152
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte 24, M0-09b
In: 0. Étage
Classification: Porte (Classification ARCHICAD)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte double asymétrique 24 (3)
In: 0. Étage
Classification: Porte (Classification ARCHICAD)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
PORTE-017
2 x M0-03

# IfcBuildingElementProxy: Poutre 1, Ossature_Poteaux/Dalle:Ossature_Poteaux/Dalle:1068375
In: 0. Étage
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 10, Poutre 7:Poutre 1:1029805
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 11, Poutre 8:Poutre 1:1029867
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 12, Poutre 9:Poutre 1:1029929
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 13, Poutre 10:Poutre 1:1029991
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 14, Poutre 11:Poutre 1:1030053
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 15, Poutre 12:Poutre 1:1030115
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 16, Poutre 13:Poutre 1:1030177
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 17, Poutre 14:Poutre 1:1030239
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 18, Ossature 1:Ossature 1:1519037
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 2, Ossature_Poteaux/Dalle1:Ossature_Poteaux/Dalle:1115131
In: R+1
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 3, Poutre rectangulaire - Béton:300 x 300 mm:1126450
In: R+1
Material: Béton - Béton coulé sur place
Pset_Poutres - Phase: Existant; Niveau de référence: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 4 (2)
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 5, Poutre 1:Poutre 1:1029495
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 6, Poutre 2:Poutre 1:1029557
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 7, Poutre 3:Poutre 1:1029619
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 8, Poutre 5:Poutre 1:1029681
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Poutre 9, Poutre 6:Poutre 1:1029743
In: TOITURE
Material: Matériau de construction IFC
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 1, Plafond de base:Plafond_Générique_60x120cm:360842
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 10, Plafond de base:Plafond_Générique_60x120cm:361048
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 100, Plafond de base:Plafond_Générique_60x120cm:624088
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 101, Plafond_Générique_Amphithéâtre:Plafond_Générique_Amphithéâtre:626372
In: R+1
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 102, Plafond de base:Plafond_Générique_60x120cm:706445
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 103, Plafond de base:Plafond_Générique_60x120cm:706621
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 104, Plafond_Sous face de plancher1:Plafond_Sous face de plancher:1120616
In: R+1
Material: Faux-plafond - Trame 600 x 600
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 105, Plafond de base:Plafond_Générique_60x120cm:1549318
In: R+1
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 106, Plafond de base:Plafond_Générique_60x120cm:474160
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 107, Plafond de base:Plafond_Générique_60x120cm:479154
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 108, Plafond de base:Plafond_Générique_60x120cm:479161
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 109, Plafond de base:Plafond_Générique_60x120cm:479168
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 11, Plafond de base:Plafond_Générique_60x120cm:361781
In: 0. Étage
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 110, Plafond de base:Plafond_Générique_60x120cm:479177
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 111, Plafond de base:Plafond_Générique_60x120cm:479184
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 112, Plafond de base:Plafond_Générique_60x120cm:479191
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 113, Plafond de base:Plafond_Générique_60x120cm:479198
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 114, Plafond de base:Plafond_Générique_60x120cm:479205
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 115, Plafond de base:Plafond_Générique_60x120cm:480326
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Revêtement 116, Plafond de base:Plafond_Générique_60x120cm:480335
In: R+2
Material: Matériau de construction IFC
Pset_Plafonds - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
