Properties of the parts of a building model (IFC2X3), part 6 of 6

# IfcOpeningElement (406)
Name | In
2 x Mur de base:Mur_Générique_28cm:536696 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
6 x Mur de base:Mur_Générique_30cm:536697 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
2 x Mur de base:Mur_Générique_18cm:536698 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
M1-08 | R+1
M1-09 | R+1
2 x Mur de base:Mur_Générique_30cm:564122 | R+1 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+1; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
M1-02 | R+1
M1-01 | R+1
M1-04 | R+1
M1-05 | R+1
M1-06 | R+1
M1-07 | R+1
M1-03 | R+1
Me 004 | R+1
4 x Me 005 | R+1
Porte_1 battant:0.90 x 2.04m:1526965 | R+2
M2-02 | R+2
M2-01 | R+2
M2-04 | R+2
M2-05 | R+2
M2-06 | R+2
M2-07 | R+2
M2-03 | R+2
Porte_1 battant:0.90 x 2.04m:716318 | R+2
Porte_1 battant:0.90 x 2.04m:716279 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:953979 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954031 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954379 | R+2
Porte_1 battant:0.90 x 2.04m:716364 | R+2
Sol:Dalle_Générique_20cm:415267:2 | R+2 | AC_Pset_RenovationAndPhasing - Renovation Status: Existing; Pset_Sols - Phase: Existant; Niveau: Niveau: R+2
Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1338490 | R+2
Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1338488 | R+2
Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1338489 | R+2
Porte_v3_2 vantaux battant:1.20 x 2.04m:961173 | R+2
Porte_v3_2 vantaux battant:1.20 x 2.04m:961120 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:953748 | R+2
Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1343274 | R+2
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1342846 | R+2
Porte_v3_2 vantaux battant:1.20 x 2.04m:960999 | R+2
Porte_v3_2 vantaux battant:1.20 x 2.04m:960954 | R+2
Porte_1 battant:0.90 x 2.04m:714579 | R+2
Porte_1 battant:0.90 x 2.04m:714780 | R+2
2 x Mur de base:Mur_Générique_18cm:272172 | R+2 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+2; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.90 x 2.04m:714382 | R+2
Porte_1 battant:0.90 x 2.04m:714527 | R+2
Porte_1 battant:0.90 x 2.04m:714830 | R+2
Porte_1 battant:0.90 x 2.04m:714992 | R+2
Mur de base:Mur_Générique_15cm:438631 | R+2 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+2; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_1 battant:0.90 x 2.04m:715038 | R+2
Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1338592 | R+2
Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1338492 | R+2
Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1338491 | R+2
Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1338487 | R+2
Porte_v3_2 vantaux battant:1.20 x 2.04m:961082 | R+2
Porte_v3_2 vantaux battant:1.20 x 2.04m:961028 | R+2
Porte_1 battant:0.90 x 2.04m:715097 | R+2
Porte_1 battant:0.70 x 2.04m:713710 | R+2
Porte_1 battant:0.70 x 2.04m:713542 | R+2
Porte_1 battant:0.70 x 2.04m:713491 | R+2
Porte_1 battant:0.80 x 2.04m:713435 | R+2
Porte_1 battant:0.80 x 2.04m:713393 | R+2
Porte_1 battant:0.80 x 2.04m:713335 | R+2
Porte_1 battant:0.80 x 2.04m:713169 | R+2
Porte_1 battant:0.80 x 2.04m:713204 | R+2
Porte_1 battant:0.70 x 2.04m:713911 | R+2
Porte_1 battant:0.70 x 2.04m:713819 | R+2
Porte_1 battant:0.80 x 2.04m:713240 | R+2
Porte_1 battant:0.70 x 2.04m:713758 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954420 | R+2
Porte_1 battant:0.90 x 2.04m:715517 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954540 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954484 | R+2
Mur de base:Mur_Générique_15cm:442855 | R+2 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+2; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
2 x Mur de base:Mur_Générique_15cm:443387 | R+2 | Pset_Murs - Phase: Existant; Niveau: Niveau: R+2; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Porte_v2_2 vantaux battant:1.40 x 2.04m:954190 | R+2
Porte_1 battant:0.90 x 2.04m:715905 | R+2
Porte_1 battant:0.90 x 2.04m:715848 | R+2
Porte_1 battant:0.90 x 2.04m:715731 | R+2
Porte_1 battant:0.90 x 2.04m:715672 | R+2
Porte_1 battant:0.90 x 2.04m:715630 | R+2
Porte_1 battant:0.90 x 2.04m:715572 | R+2
Porte_1 battant:0.90 x 2.04m:715317 | R+2
Porte_1 battant:0.90 x 2.04m:715296 | R+2
Porte_1 battant:0.90 x 2.04m:715230 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954086 | R+2
Porte_1 battant:0.90 x 2.04m:715952 | R+2
Porte_1 battant:0.90 x 2.04m:716162 | R+2
Porte_1 battant:0.90 x 2.04m:716211 | R+2
Porte_1 battant:0.90 x 2.04m:716083 | R+2
Porte_1 battant:0.90 x 2.04m:716027 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954263 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954307 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954137 | R+2
Porte_1 battant:0.90 x 2.04m:715768 | R+2
Porte_1 battant:0.90 x 2.04m:715457 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954579 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:954620 | R+2
Porte_1 battant:0.90 x 2.04m:715411 | R+2
Porte_1 battant:0.90 x 2.04m:715369 | R+2
Porte_1 battant:0.90 x 2.04m:715810 | R+2
Porte d'ascenseur:1.00 x 2.04 m:1405349 | R+2
Porte_1 battant:0.90 x 2.04m:714718 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:953850 | R+2
Porte_v2_2 vantaux battant:1.40 x 2.04m:953650 | R+2
M2-26 | R+2
M2-25 | R+2
M2-19 | R+2
M2-20 | R+2
M2-21 | R+2
M2-22 | R+2
M2-23 | R+2
M2-24 | R+2
M2-08 | R+2
M2-09 | R+2
M2-10 | R+2
M2-11 | R+2
M2-12 | R+2
M2-13 | R+2
M2-14 | R+2
M2-15 | R+2
M2-16 | R+2
M2-17 | R+2
M2-18 | R+2
3 x PORTE-017 | TOITURE
Mur de base:Mur_Générique_18cm:272172 | TOITURE | Pset_Murs - Phase: Existant; Niveau: Niveau: TOITURE; AC_Pset_RenovationAndPhasing - Renovation Status: Existing
7 x Me 011 | TOITURE

# IfcStair (52)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In | Material | Phase
Escalier coulé sur place:Escalier:386295 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Au Mur:1515499 | 0. Étage | Pin (1) | Existant
Garde-corps:Au Mur:1515503 | 0. Étage | Pin (1) | Existant
Escalier coulé sur place:Escalier:389846 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Type Bateau:391429 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Au Mur:391433 | 0. Étage | Pin (1) | Existant
Escalier coulé sur place:Escalier:427353 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Garde-corps_Intérieur_ENSAM:429090 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Garde-corps_Intérieur_ENSAM:429094 | 0. Étage | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:430442 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Garde-corps_Intérieur_ENSAM:431382 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Garde-corps_Intérieur_ENSAM:431386 | 0. Étage | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:453678 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Type Bateau:453712 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Au Mur:453715 | 0. Étage | Pin (1) | Existant
Escalier coulé sur place:Escalier:763564 Run 1 | 0. Étage | Maçonnerie - Béton
Escalier coulé sur place:Escalier:722109 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Type Bateau:1123479 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Type Bateau:1123483 | 0. Étage | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:576384 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Garde_corps_Extérieur_ENSAM:578682 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Garde_corps_Extérieur_ENSAM:578686 | 0. Étage | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:578883 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Garde_corps_Extérieur_ENSAM:579258 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Garde_corps_Extérieur_ENSAM:579262 | 0. Étage | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:1032113 Run 1 | 0. Étage | Maçonnerie - Béton
Garde-corps:Type Bateau:1032539 | 0. Étage | Matériau de construction IFC | Existant
Garde-corps:Type Bateau:1032543 | 0. Étage | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:1515744 Run 1 | 0. Étage | Maçonnerie - Béton
Escalier coulé sur place:Escalier:429179 Run 1 | R+1 | Maçonnerie - Béton
Garde-corps:Garde-corps_Intérieur_ENSAM:430385 | R+1 | Matériau de construction IFC | Existant
Garde-corps:Garde-corps_Intérieur_ENSAM:430389 | R+1 | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:431722 Run 1 | R+1 | Maçonnerie - Béton
Garde-corps:Garde-corps_Intérieur_ENSAM:432314 | R+1 | Matériau de construction IFC | Existant
Garde-corps:Garde-corps_Intérieur_ENSAM:432318 | R+1 | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:569879 Run 1 | R+1 | Maçonnerie - Béton
Garde-corps:Garde_corps_Extérieur_ENSAM:573363 | R+1 | Matériau de construction IFC | Existant
Garde-corps:Garde_corps_Extérieur_ENSAM:573367 | R+1 | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:579447 Run 1 | R+1 | Maçonnerie - Béton
Garde-corps:Garde_corps_Extérieur_ENSAM:579554 | R+1 | Matériau de construction IFC | Existant
Garde-corps:Garde_corps_Extérieur_ENSAM:579558 | R+1 | Matériau de construction IFC | Existant
Escalier coulé sur place:Escalier:1662589 Run 1 | R+1 | Maçonnerie - Béton
Garde-corps:Au Mur:1664027 | R+1 | Pin (1) | Existant
Escalier coulé sur place:Escalier:1399736 Run 1 | R+1 | Maçonnerie - Béton
Garde-corps:Type Bateau:1399770 | R+1 | Matériau de construction IFC | Existant
Garde-corps:Au Mur:1399773 | R+1 | Pin (1) | Existant
Escalier coulé sur place:Escalier:1396196 Run 1 | R+1 | Maçonnerie - Béton
Garde-corps:Type Bateau:1396257 | R+1 | Matériau de construction IFC | Existant
Garde-corps:Au Mur:1396260 | R+1 | Pin (1) | Existant
Escalier coulé sur place:Escalier:574792 Run 1 | R+2 | Maçonnerie - Béton
Garde-corps:Garde_corps_Extérieur_ENSAM:574959 | R+2 | Matériau de construction IFC | Existant
Garde-corps:Garde_corps_Extérieur_ENSAM:574963 | R+2 | Matériau de construction IFC | Existant

# IfcStair: Escalier coulé sur place:Monobloc:189391 (19)
Pset_Escaliers - Phase: Existant
Name (Escalier coulé sur place:Escalier:...) | In
386295 | 0. Étage
389846 | 0. Étage
427353 | 0. Étage
430442 | 0. Étage
453678 | 0. Étage
763564 | 0. Étage
722109 | 0. Étage
576384 | 0. Étage
578883 | 0. Étage
1032113 | 0. Étage
1515744 | 0. Étage
429179 | R+1
431722 | R+1
569879 | R+1
579447 | R+1
1662589 | R+1
1399736 | R+1
1396196 | R+1
574792 | R+2
