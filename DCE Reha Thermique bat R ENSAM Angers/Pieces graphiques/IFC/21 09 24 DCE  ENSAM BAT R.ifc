Properties of the parts of a building model (IFC2X3), part 1 of 6

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Building Material Properties: Off], Option [Element Parameters: Off], Option [Component Parameters: Off], Option [IFC Base Quantities: Off], Option [Door Window Parameters: Off], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: Z:\SA-2020-05 Rénovation énergétique Bât R ENSAM\07 DCE\DCE\IFC\21 09 03 ENSAM BAT R Angers V 24 PROJET FINAL.ifc
Time: 2021-09-27T16:41:40
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD 24.0.0 FRA FULL Windows version (IFC add-on version: 5000 FRA FULL).
Authorization: The authorising person

# IfcProject, BATIMENT R DE L'E.N.S.A.M.
Description: REHABILITATION THERMIQUE; Phase: PC

# IfcSite, Site
Description: ANGERS; RefLatitude: 47, 29, 32, 434000; RefLongitude: 0, -33, -23, -366000; RefElevation: 123.4 m

# IfcBuildingStorey (4)
In: Bâtiment
Name | LongName | Elevation (m)
0. Étage | RDC | 0
R+1 | R+1 | 3.4
R+2 | R+2 | 6.82
TOITURE | TOITURE | 9.6

# IfcBuildingElementPart (101)
Name | In | Material
Finition int - Plaque de plâtre + | 0. Étage | Finition int - Plaque de plâtre +
Isolation - Laine de verre | 0. Étage | Isolation - Laine de verre
10 x Béton | 0. Étage | Béton
10 x Isolation | 0. Étage | Isolation
16 x Vide pour façade ventilée | 0. Étage | Vide pour façade ventilée
Béton non | 0. Étage | Béton non
Isolation - Polystyrène extrudé | 0. Étage | Isolation - Polystyrène extrudé
Etanchéité - 03 | 0. Étage | Etanchéité - 03
10 x Béton | R+1 | Béton
10 x Isolation | R+1 | Isolation
16 x Vide pour façade ventilée | R+1 | Vide pour façade ventilée
6 x Béton | R+2 | Béton
6 x Isolation | R+2 | Isolation
12 x Vide pour façade ventilée | R+2 | Vide pour façade ventilée

# IfcBuildingElementProxy: 01.1a - MI Béton bat R CASSETTES 420 (22)
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_18cm:...) | In
8 x 1527031 | 0. Étage
8 x 1527031 | R+1
6 x 1527031 | R+2

# IfcBuildingElementProxy: 01.1a - MI Béton bat R SOUS MUR RIDEAU 330 (4)
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_18cm:...) | In
2 x 1527031 | 0. Étage
2 x 1527031 | R+1

# IfcBuildingElementProxy: A_Dalle 1% loggia 250, DALLE-011
In: 0. Étage
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: A_Doublage 10 cm 100, Mur de base:Mur_Générique_18cm:1527031
In: 0. Étage
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Acier (387)
Material: Acier
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
32 x FORME-010 | 0. Étage
8 x FORME-014 | 0. Étage
16 x FORME-011 | 0. Étage
16 x FORME-009 | 0. Étage
22 x FORME-009 | R+1
11 x FORME-014 | R+1
44 x FORME-010 | R+1
22 x FORME-011 | R+1
24 x FORME-014 | R+2
96 x FORME-010 | R+2
48 x FORME-011 | R+2
48 x FORME-009 | R+2

# IfcBuildingElementProxy: Aluminium 100 x 50 (46)
In: 0. Étage
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | Classification
35 x POTEAU-009 | Poteau (Classification ARCHICAD)
11 x POUTRE-014

# IfcBuildingElementProxy: Aluminium 120 x 30 (24)
In: 0. Étage
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 120 x 50 (51)
In: 0. Étage
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
2 x POTEAU-008 | Classification: Poteau (Classification ARCHICAD)
49 x POUTRE-014

# IfcBuildingElementProxy: Aluminium 240 x 20 (28)
In: 0. Étage
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 260 x 20 (16)
In: 0. Étage
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 320 x 50, POUTRE-014
In: 0. Étage
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 50 x 100 (6)
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 50 x 120 (2)
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 50 x 200 (10)
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 50 x 210 (15)
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium 50 x 50 (48)
In: 0. Étage
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
12 x POTEAU-008 | Classification: Poteau (Classification ARCHICAD)
12 x POUTRE-014
24 x POUTRE-015

# IfcBuildingElementProxy: Aluminium 80 x 80 (26)
In: R+2
Classification: Poteau (Classification ARCHICAD); Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Aluminium D640 (7)
In: R+2
Material: Aluminium
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Asphalte, TERRAIN-007
In: 0. Étage
Material: Asphalte
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Baie générique 2019 (45)
Classification: Fenêtre (Classification ARCHICAD)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
M0-08 | 0. Étage
M0-09 | 0. Étage
M0-02 | 0. Étage
M0-01 | 0. Étage
M0-04 | 0. Étage
M0-05 | 0. Étage
M0-06 | 0. Étage
M0-07 | 0. Étage
M1-11 | R+1
M1-10 | R+1
M1-08 | R+1
M1-09 | R+1
M1-02 | R+1
M1-01 | R+1
M1-04 | R+1
M1-05 | R+1
M1-06 | R+1
M1-07 | R+1
M1-03 | R+1
M2-02 | R+2
M2-01 | R+2
M2-04 | R+2
M2-05 | R+2
M2-06 | R+2
M2-07 | R+2
M2-03 | R+2
M2-26 | R+2
M2-25 | R+2
M2-19 | R+2
M2-20 | R+2
M2-21 | R+2
M2-22 | R+2
M2-23 | R+2
M2-24 | R+2
M2-08 | R+2
M2-09 | R+2
M2-10 | R+2
M2-11 | R+2
M2-12 | R+2
M2-13 | R+2
M2-14 | R+2
M2-15 | R+2
M2-16 | R+2
M2-17 | R+2
M2-18 | R+2

# IfcBuildingElementProxy: Barrière 32, Garde-corps:Garde-corps_Intérieur_ENSAM:1115176
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 33, Garde-corps:Garde-corps_Intérieur_ENSAM:1116765
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 34, Garde-corps:Garde-corps_Intérieur_ENSAM:1116792
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 35, Garde-corps:Garde-corps_Intérieur_ENSAM:1116810
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 36, Garde-corps:Garde-corps_Intérieur_ENSAM:1116834
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 37, Garde-corps:Garde-corps_Intérieur_ENSAM:1116852
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 38, Garde-corps:Garde-corps_Intérieur_ENSAM:1116879
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 39, Garde-corps:Garde-corps_Intérieur_ENSAM:1116903
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 40, Garde-corps:Garde-corps_Intérieur_ENSAM:1404384
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 41, Garde-corps:Garde_corps_Extérieur_ENSAM:1405549
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 42, Garde-corps:Remplissage Inférieur:1405625
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 43, Garde-corps:Garde_corps_Extérieur_ENSAM:1405757
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 44, Garde-corps:Garde_corps_Extérieur_ENSAM:1405789
In: R+1
Material: Métal - Acier inoxydable, poli
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 45, Garde-corps:Garde-corps_Intérieur_ENSAM:1624968
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 46, Garde-corps:Type Bateau:1663713
In: R+1
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 49, Garde-corps:Garde-corps_Intérieur_ENSAM:1117280
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 50, Garde-corps:Garde-corps_Intérieur_ENSAM:1117632
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 51, Garde-corps:Garde-corps_Intérieur_ENSAM:1117997
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 52, Garde-corps:Garde-corps_Intérieur_ENSAM:1118331
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 53, Garde-corps:Garde-corps_Intérieur_ENSAM:1118670
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 54, Garde-corps:Garde-corps_Intérieur_ENSAM:1118957
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 55, Garde-corps:Garde_corps_Extérieur_ENSAM:1405906
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 56, Garde-corps:Garde_corps_Extérieur_ENSAM:1405952
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 57, Garde-corps:Garde_corps_Extérieur_ENSAM:1406075
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 58, Garde-corps:Remplissage Inférieur:1406108
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 59, Garde-corps:Garde_corps_Extérieur_ENSAM:1406236
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 60, Garde-corps:Garde_corps_Extérieur_ENSAM:1406269
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 61, Garde-corps:Type Bateau:1514936
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 62, Garde-corps:Type Bateau:1515304
In: R+2
Material: Matériau de construction IFC
Pset_Garde-corps - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Barrière 63, Garde-corps_Passerelle:Garde-corps_Passerelle:761579
In: TOITURE
Material: Métal_Passerelle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Béton - Béton coulé sur place 300 x 300 (6)
Material: Béton - Béton coulé sur place
Pset_Poutres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Poutre rectangulaire - Béton:300 x 300 mm:...) | In | Niveau de référence
1126330 | R+1 | Niveau: R+1
1126485 | R+2 | Niveau: R+2
1126402 | R+2 | Niveau: R+2
1126560 | R+2 | Niveau: R+2
1126973 | R+2 | Niveau: R+2
1126364 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Béton - non 10 (3)
In: 0. Étage
Material: Béton - non
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
2 x DALLE-014
DALLE-015

# IfcBuildingElementProxy: Béton - non 600 (11)
In: 0. Étage
Material: Béton - non
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Béton 1000, DALLE-017
In: 0. Étage
Material: Béton
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Béton 180 (8)
Material: Béton
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_18cm:...) | In | Niveau
3 x 350145 | 0. Étage | Niveau: RDC
1527031 | 0. Étage | Niveau: RDC
1527031 | R+1 | Niveau: RDC
2 x 498265 | R+2 | Niveau: R+1
1527031 | R+2 | Niveau: RDC

# IfcBuildingElementProxy: Caoutchouc (98)
In: 0. Étage
Material: Caoutchouc
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
30 x DALLE-020
17 x DALLE-021
10 x DALLE-022
7 x DALLE-024
5 x DALLE-019
6 x DALLE-023
3 x DALLE-025
4 x DALLE-017
4 x DALLE-018
2 x DALLE-026
4 x DALLE-027
3 x DALLE-028
2 x DALLE-029
DALLE-030

# IfcBuildingElementProxy: Dalle 1, Sol:Rampe_Générique_20cm:760974
In: 0. Étage
Material: Maçonnerie - Béton_Rampe
Pset_Sols - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Dalle 2, Sol:Rampe_Générique_20cm:761006
In: 0. Étage
Material: Matériau de construction IFC
Pset_Sols - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Dalle 3, Sol:Rampe_Générique_20cm:1517069
In: 0. Étage
Material: Matériau de construction IFC
Pset_Sols - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Dalle 4, Sol:Rampe_Générique_20cm:1527849
In: 0. Étage
Material: Matériau de construction IFC
Pset_Sols - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Dalle 5, Passerelle:Dalle_Passerelle:292031
In: TOITURE
Material: Matériau de construction IFC
Pset_Sols - Phase: Existant; Niveau: Niveau: TOITURE
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 1, Porte_1 battant:0.90 x 2.04m:716882
In: 0. Étage
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC ht / +0.40m
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 100, Raidisseurs 7:Raidisseurs 1:995359
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 101, Raidisseurs 8:Raidisseurs 1:995662
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 104, Equimement de ventilation:Equimement de ventilation 1:256757
In: TOITURE
Material: Matériau de construction IFC
Pset_Equipements - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 105, Equipement de ventilation 2:Equipement de ventilation 2:274859
In: TOITURE
Material: Matériau de construction IFC
Pset_Equipements - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 106, Equipement de ventilation 3:Equipement de ventilation 3:283440
In: TOITURE
Material: Matériau de construction IFC
Pset_Equipements - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 107 (19)
In: TOITURE
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Puits de lumière_Générique:1.30 x 1.30m:...)
672128
672124
672123
2 x 672121
672120
672119
672118
672117
672116
672115
672114
672113
672112
672111
672110
672109
672108
672106

# IfcBuildingElementProxy: Elément Modèle 108 (2)
In: TOITURE
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Puits de lumière_Générique:1.30 x 1.30m:...)
672127
672125

# IfcBuildingElementProxy: Elément Modèle 2 (6)
In: 0. Étage
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (1 Vantaux fixe - 1.80X2.20:1.80m x 2.20m:...)
1028096
1002734
1028092
1028093
1028094
1028095

# IfcBuildingElementProxy: Elément Modèle 3 (2)
In: 0. Étage
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC ht / +0.40m
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Porte_v4_2 vantaux battant:1.80 x 2.04m:...)
859145
859144

# IfcBuildingElementProxy: Elément Modèle 31 (2)
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (3 Vantaux coul. - 3.505X1.30:3.505m x 1.30m:...) | In
914132 | 0. Étage
914735 | R+1

# IfcBuildingElementProxy: Elément Modèle 32 (2)
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (2 Vantaux coul. - 2.285X1.30:2.285m x 1.30m:...) | In
834256 | 0. Étage
840643 | R+1

# IfcBuildingElementProxy: Elément Modèle 33, PVC 2-Panneau Vitré - Traverse:1.47m x 2.10m:732712
In: 0. Étage
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 34 (2)
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (4 Vantaux coul. - 4.21X1.30:4.21m x 1.30m:...) | In
920929 | 0. Étage
920554 | R+1

# IfcBuildingElementProxy: Elément Modèle 4 (4)
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Porte_1 battant:0.90 x 2.04m:...) | In | Niveau
708727 | 0. Étage | Niveau: RDC
858053 | 0. Étage | Niveau: RDC ht / +0.40m
712024 | R+1 | Niveau: R+1
715157 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Elément Modèle 43 (2)
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Porte_v3_2 vantaux battant:1.20 x 2.04m:...) | In | Niveau
960734 | R+1 | Niveau: R+1
960810 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Elément Modèle 44 (2)
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Porte_v2_2 vantaux battant:1.40 x 2.04m:...) | In | Niveau
953214 | R+1 | Niveau: R+1
953698 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Elément Modèle 47, 1 Vantaux fixe - 1.42X1.30:1.42m x 1.30m:929478
In: R+1
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 48 (2)
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (3 Vantaux coul. - 4.42X1.30:4.42m x 1.30m:...) | In
935195 | R+1
935513 | R+2

# IfcBuildingElementProxy: Elément Modèle 5 (2)
In: 0. Étage
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Porte_1 battant:0.90 x 2.04m:...)
708471
708222

# IfcBuildingElementProxy: Elément Modèle 51 (4)
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (PVC 2-Panneau Vitré - Traverse:1.47m x 2.10m:...) | In | Niveau
660639 | R+1 | Niveau: R+1
717208 | R+1 | Niveau: R+1
717421 | R+2 | Niveau: R+2
717315 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Elément Modèle 52, 3 Vantaux coul. - 3.55X1.30:3.55m x 1.30m:923746
In: R+1
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 59, 4 Vantaux coul. - 5.06X1.30:5.06m x 1.30m:883624
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 6 (2)
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Porte_v3_2 vantaux battant:1.20 x 2.04m:...) | In | Niveau
957501 | 0. Étage | Niveau: RDC
960897 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Elément Modèle 60, 4 Vantaux coul. - 5.30X1.30:5.30m x 1.30m:877798
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 61 (8)
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (4 Vantaux coul. - 5.42X1.30:5.42m x 1.30m:...)
824894
824624
824508
824414
824324
823601
824748
874770

# IfcBuildingElementProxy: Elément Modèle 62 (3)
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:...)
1343607
1343506
1343167

# IfcBuildingElementProxy: Elément Modèle 63, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1342942
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 7 (2)
In: 0. Étage
Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Porte_v2_2 vantaux battant:1.40 x 2.04m:...)
952264
952155

# IfcBuildingElementProxy: Elément Modèle 8 (6)
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (4 Vantaux coul. - 5.42X1.30:5.42m x 1.30m:...) | In
822682 | 0. Étage
874689 | 0. Étage
824149 | 0. Étage
874687 | R+1
823186 | R+1
824323 | R+1

# IfcBuildingElementProxy: Elément Modèle 9 (2)
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (2 Vantaux coul. - 2.285X1.30:2.42m x 1.30m:...) | In
837619 | 0. Étage
840644 | R+1

# IfcBuildingElementProxy: Elément Modèle 91, 4 Vantaux coul. - 5.245X1.30:5.245m x 1.30m:843802
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 92, 3 Vantaux coul. - 3.545X1.30:3.545m x 1.30m:899544
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 93, 3 Vantaux coul. - 3.55X1.30:3.55m x 1.30m:924109
In: R+2
Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 94, Raidisseurs 1:Raidisseurs 1:983879
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 95, Raidisseurs 2:Raidisseurs 1:986946
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 96, Raidisseurs 3:Raidisseurs 1:993832
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 97, Raidisseurs 4:Raidisseurs 1:994440
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 98, Raidisseurs 5:Raidisseurs 1:994650
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Elément Modèle 99, Raidisseurs 6:Raidisseurs 1:995148
In: R+2
Material: Matériau de construction IFC
Pset_Raidisseurs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 10, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337339
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 11, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337341
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 12, Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337323
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 13, Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1337324
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 14, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337327
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 15, Fenêtre_Classe-couloir_v2.2:2.50 x 0.80 m:1361910
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 16, Fenêtre_Classe-couloir_v2.2:1.25 x 0.80 m:1366859
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 18, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1358992
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 19, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1359034
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 20, Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1359228
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 21, Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1359272
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 22, Fenêtre_Classe-couloir_v4:5.00 x 0.80 m:1513977
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 23, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337344
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 24, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337343
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 25, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337338
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 26, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337331
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 27, Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337321
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 28, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337329
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 29, Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1337326
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 30, Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337322
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 31, Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1359446
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 32, Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1359321
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 33, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1359100
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 34, T-2 Vantaux coulissant:2.55 x 0.80 cm:939840
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 35, T-2 Vantaux coulissant:2.48 x 0.80 cm:938935
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 36, T-2 Vantaux coulissant:2.60 x 0.80 cm:941255
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 37, T-2 Vantaux coulissant:2.60 x 0.80 cm:941077
In: R+1
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 38, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1338490
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 39, Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1338488
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 4, Fenêtre_Ouverture avec volé roulant:3.18 x 1.50 m:1185778
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 40, Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1338489
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 41, Fenêtre_Classe-couloir_v2:2.50 x 0.70 m:1343274
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 42, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1342846
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 43, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1338592
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 44, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1338492
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 45, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1338491
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 46, Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1338487
In: R+2
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 6, Fenêtre_Ouverture avec volé roulant:4.93 x 1.50 m:1187858
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 7, Fenêtre_Classe-couloir_v4:5.00 x 0.70 m:1337318
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 8, Fenêtre_Classe-couloir_v3:3.75 x 0.70 m:1337330
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre (Mur) 9, Fenêtre_Classe-couloir_v1:1.25 x 0.70 m:1337336
In: 0. Étage
Classification: Fenêtre (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Fenêtres - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Herbe, FORME-009
In: 0. Étage
Material: Herbe
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Herbe 10 (3)
In: 0. Étage
Material: Herbe
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Isolation - Polyuréthane (extérieur) (13)
In: 0. Étage
Material: Isolation - Polyuréthane (extérieur)
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Maçonnerie - Béton 200 (25)
Material: Maçonnerie - Béton
Pset_Sols - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Sol:Dalle_Générique_20cm:...) | In | Niveau
723750:3 | 0. Étage | Niveau: RDC
723750 | 0. Étage | Niveau: RDC
723750:2 | 0. Étage | Niveau: RDC
760806 | 0. Étage | Niveau: RDC
760806:2 | 0. Étage | Niveau: RDC
1527016 | 0. Étage | Niveau: RDC
380740 | R+1 | Niveau: R+1
380740:2 | R+1 | Niveau: R+1
380740:3 | R+1 | Niveau: R+1
380740:4 | R+1 | Niveau: R+1
380740:5 | R+1 | Niveau: R+1
625425 | R+1 | Niveau: R+1
1466548 | R+1 | Niveau: R+1
1466548:2 | R+1 | Niveau: R+1
1662550 | R+1 | Niveau: R+1
1467116:2 | R+2 | Niveau: R+2
1467116 | R+2 | Niveau: R+2
625026 | R+2 | Niveau: R+2
415267 | R+2 | Niveau: R+2
415267:2 | R+2 | Niveau: R+2
415267:3 | R+2 | Niveau: R+2
415267:4 | R+2 | Niveau: R+2
415267:5 | R+2 | Niveau: R+2
536852:2 | TOITURE | Niveau: TOITURE
536852 | TOITURE | Niveau: TOITURE

# IfcBuildingElementProxy: Maçonnerie - Béton 500, Sol:Dalle_Générique_50cm:1517056
In: 0. Étage
Material: Maçonnerie - Béton
Pset_Sols - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Maçonnerie - Béton coulé sur place 300 x 300 (12)
Classification: Poteau (Classification ARCHICAD); Material: Maçonnerie - Béton coulé sur place
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Poteau béton - Carré:300mm x 300mm:...) | In
1125224 | 0. Étage
1125234 | 0. Étage
1125317 | 0. Étage
1125467 | 0. Étage
1125522 | R+1
1125524 | R+1
1125526 | R+1
1125528 | R+1
1125621 | R+2
1125619 | R+2
1125617 | R+2
1125615 | R+2

# IfcBuildingElementProxy: Maçonnerie - Béton coulé sur place D180, Poteau_Générique_Arrondi:b=180mm:374617
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: Maçonnerie - Béton coulé sur place
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Maçonnerie - Béton coulé sur place D300 (5)
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: Maçonnerie - Béton coulé sur place
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Poteau_Générique_Arrondi:b=300mm:...)
373842
374077
374229
374558
374592

# IfcBuildingElementProxy: Maçonnerie - Béton coulé sur place D400 (38)
Classification: Poteau (Classification ARCHICAD); Material: Maçonnerie - Béton coulé sur place
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Poteau_Générique_Arrondi:b=400mm:...) | In
372132 | 0. Étage
372500 | 0. Étage
372622 | 0. Étage
372844 | 0. Étage
372977 | 0. Étage
373081 | 0. Étage
373157 | 0. Étage
373296 | 0. Étage
373369 | 0. Étage
373408 | 0. Étage
373545 | 0. Étage
373562 | 0. Étage
373703 | 0. Étage
373753 | 0. Étage
373772 | 0. Étage
542655 | R+1
542657 | R+1
542659 | R+1
542661 | R+1
542663 | R+1
542665 | R+1
542667 | R+1
542669 | R+1
542671 | R+1
542673 | R+1
542675 | R+1
542677 | R+1
542679 | R+1
542681 | R+1
542683 | R+1
982583 | R+2
982526 | R+2
982478 | R+2
982402 | R+2
982351 | R+2
982294 | R+2
982192 | R+2
981638 | R+2

# IfcBuildingElementProxy: Maçonnerie - Béton_Rampe 110 (3)
In: 0. Étage
Material: Maçonnerie - Béton_Rampe
Pset_Sols - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Sol:Rampe_Générique_20cm:...)
1528112
1528136
1528226

# IfcBuildingElementProxy: Mur 1, Murs 1:Murs 1:271165
In: 0. Étage
Material: Révetement
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 10, Murs 2:Murs 2:392707
In: 0. Étage
Material: Mur par défaut
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 11, Dessus de murs:Dessus de murs:1121952
In: 0. Étage
Material: Mur par défaut
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 12, Mur de base:Mur_Générique_28cm:393143
In: R+1
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 13, Mur de base:Mur_Générique_28cm:393155
In: R+1
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 14, Mur de base:Mur_Générique_18cm:397828
In: R+1
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 15, Mur de base:Mur_Générique_18cm:407375
In: R+1
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 17, Mur de base:Mur_Générique_28cm:716695
In: R+1
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 18, Mur de base:Mur_Générique_18cm:421794
In: R+2
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 19, Mur de base:Mur_Générique_28cm:422396
In: R+2
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 2, Mur de base:Mur_Générique_18cm:272177
In: 0. Étage
Material: Révetement
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 20, Mur de base:Mur_Générique_18cm:436494
In: R+2
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 21, Mur de base:Mur_Générique_18cm:437597
In: R+2
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 22, Mur de base:Mur_Générique_28cm:442416
In: R+2
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 23, Mur de base:Mur_Générique_9cm:474102
In: R+2
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 24, Mur de base:Mur_Générique_18cm:474103
In: R+2
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: R+2
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 25, Mur de base:Mur/Acrotere_Générique_28cm:553538
In: TOITURE
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: TOITURE
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 26, Mur de base:Mur/Acrotere_Générique_28cm:557447
In: TOITURE
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: TOITURE
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 3, Mur de base:Mur_Générique_28cm:317596
In: 0. Étage
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 4, Mur de base:Mur_Générique_18cm:321402
In: 0. Étage
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 5, Mur de base:Mur_Générique_10cm:321404
In: 0. Étage
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 6, Mur de base:Mur_Générique_18cm:324406
In: 0. Étage
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 7, Mur de base:Mur_Générique_10cm:325411
In: 0. Étage
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur 9, Mur de base:Mur_Générique_18cm:341962
In: 0. Étage
Material: Matériau de construction IFC
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur par défaut 160 (4)
Material: Mur par défaut
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_16cm:...) | In | Niveau
2 x 334570 | 0. Étage | Niveau: RDC
1663516 | R+1 | Niveau: R+1
638157 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Mur par défaut 330, Mur de base:Mur_Générique_33cm:612858
In: 0. Étage
Material: Mur par défaut
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Mur par défaut 340 (3)
In: R+1
Material: Mur par défaut
Pset_Murs - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_34cm:...)
1421239
1490700
1490857

# IfcBuildingElementProxy: Mur par défaut 360 (3)
Material: Mur par défaut
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_36cm:...) | In | Niveau
341589 | 0. Étage | Niveau: RDC
499899 | R+1 | Niveau: R+1
505559 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Mur par défaut 50 (3)
In: 0. Étage
Material: Mur par défaut
Pset_Murs - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_5cm:...)
272187
1527054
1527055

# IfcBuildingElementProxy: Mur par défaut 70 (42)
Material: Mur par défaut
Pset_Murs - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Mur de base:Mur_Générique_7cm:...) | In | Niveau
330298 | 0. Étage | Niveau: RDC
330391 | 0. Étage | Niveau: RDC
330470 | 0. Étage | Niveau: RDC
330572 | 0. Étage | Niveau: RDC
330647 | 0. Étage | Niveau: RDC
330690 | 0. Étage | Niveau: RDC
330756 | 0. Étage | Niveau: RDC
340765 | 0. Étage | Niveau: RDC
340829 | 0. Étage | Niveau: RDC
340908 | 0. Étage | Niveau: RDC
341036 | 0. Étage | Niveau: RDC
341110 | 0. Étage | Niveau: RDC
341194 | 0. Étage | Niveau: RDC
341270 | 0. Étage | Niveau: RDC
396043 | R+1 | Niveau: R+1
396135 | R+1 | Niveau: R+1
396190 | R+1 | Niveau: R+1
396240 | R+1 | Niveau: R+1
396310 | R+1 | Niveau: R+1
396369 | R+1 | Niveau: R+1
396433 | R+1 | Niveau: R+1
407934 | R+1 | Niveau: R+1
408031 | R+1 | Niveau: R+1
408091 | R+1 | Niveau: R+1
408135 | R+1 | Niveau: R+1
408198 | R+1 | Niveau: R+1
408261 | R+1 | Niveau: R+1
408368 | R+1 | Niveau: R+1
440342 | R+2 | Niveau: R+2
440414 | R+2 | Niveau: R+2
440494 | R+2 | Niveau: R+2
440546 | R+2 | Niveau: R+2
440638 | R+2 | Niveau: R+2
440697 | R+2 | Niveau: R+2
440757 | R+2 | Niveau: R+2
440940 | R+2 | Niveau: R+2
441005 | R+2 | Niveau: R+2
441080 | R+2 | Niveau: R+2
441214 | R+2 | Niveau: R+2
441284 | R+2 | Niveau: R+2
441370 | R+2 | Niveau: R+2
441436 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Métal 80 (5)
Material: Métal
Pset_Sols - Phase: Existant
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Sol:Dalle_Générique_8cm:...) | In | Niveau
1393533 | R+1 | Niveau: R+1
1393533:2 | R+1 | Niveau: R+1
1393556 | R+2 | Niveau: R+2
1393547 | R+2 | Niveau: R+2
574491 | R+2 | Niveau: R+2

# IfcBuildingElementProxy: Métal perforé clair (29)
In: 0. Étage
Material: Métal perforé clair
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Métal perforé foncé (18)
In: 0. Étage
Material: Métal perforé foncé
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Métal_Passerelle (112)
In: 0. Étage
Material: Métal_Passerelle
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
13 x DALLE-020
12 x DALLE-030
8 x DALLE-025
7 x DALLE-027
12 x DALLE-023
8 x DALLE-024
10 x DALLE-022
8 x DALLE-026
4 x DALLE-028
4 x DALLE-029
6 x DALLE-031
8 x DALLE-021
2 x DALLE-016
2 x DALLE-017
2 x DALLE-018
3 x DALLE-019
DALLE-032
DALLE-033
DALLE-034

# IfcBuildingElementProxy: PVC - Gris foncé 180 x 163 (6)
In: 0. Étage
Classification: Poteau (Classification ARCHICAD); Material: PVC - Gris foncé
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name (Poteau béton - Rectangulaire:180 x 160.32 mm:...)
1622084
1622399
1622431
1622478
1622505
1622523

# IfcBuildingElementProxy: Porte (Mur) 1, Porte_1 battant:0.80 x 2.04m:709129
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 10, Porte_1 battant:0.90 x 2.04m:708656
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 100, Porte_1 battant:0.90 x 2.04m:711100
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 101, Porte_1 battant:0.90 x 2.04m:711677
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 102, Porte_1 battant:0.90 x 2.04m:711632
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 103, Porte_1 battant:0.90 x 2.04m:711587
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 104, Porte_1 battant:0.90 x 2.04m:711823
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 105, Porte_1 battant:0.90 x 2.04m:711517
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 106, Porte_1 battant:0.90 x 2.04m:712597
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 107, Porte_1 battant:0.90 x 2.04m:711276
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 108, Porte_1 battant:0.90 x 2.04m:711211
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 109, Porte_1 battant:0.90 x 2.04m:712743
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 11, Porte_1 battant:0.90 x 2.04m:708608
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 110, Porte_1 battant:0.90 x 2.04m:712666
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 111, Porte_1 battant:0.90 x 2.04m:710850
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 112, Porte_1 battant:0.90 x 2.04m:710751
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 113 (2)
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 114, Porte_1 battant:0.90 x 2.04m:710589
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 115, Porte_1 battant:0.90 x 2.04m:710541
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 116, Porte_1 battant:0.90 x 2.04m:710339
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 117, Porte_1 battant:0.90 x 2.04m:712434
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 118, Porte_1 battant:0.90 x 2.04m:711477
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 119, Porte_1 battant:0.90 x 2.04m:711389
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 12, Porte_1 battant:0.90 x 2.04m:708562
In: 0. Étage
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: RDC
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Porte (Mur) 120, Porte_v3_2 vantaux battant:1.20 x 2.04m:960668
In: R+1
Classification: Porte (Classification ARCHICAD); Material: Matériau de construction IFC
Pset_Portes - Phase: Existant; Niveau: Niveau: R+1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
